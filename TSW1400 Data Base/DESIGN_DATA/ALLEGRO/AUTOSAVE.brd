# Allegro board AUTOSAVE.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
C-0603_X2Y
  rect 0.635x0.762 smd: A(-0.83,0) B(0.83,0)
  rect 0.508x0.254 smd: G1(0,0.635) G2(0,-0.635)
CA-AVE-0603-8
  rect 0.6x1.05 smd: 1(-1.2,-0.85) 2(-0.4,-0.85) 3(0.4,-0.85) 4(1.2,-0.85) 5(1.2,0.85) 6(0.4,0.85) 7(-0.4,0.85) 8(-1.2,0.85)
CAP_SMD_8MM
  rect 1.6x3.912 smd: 1(0,3.353) 2(0,-3.099)
CAP_SMD_12_5MM
  rect 1.6x5.842 smd: 1(0,4.864) 2(0,-4.864)
CON_SMRT_USBMNE20_F
  round 0.025 hole 0.457 unplated: (0.65,2.2) (0.65,-2.2)
  rect 2.311x0.508 smd: 1(3.45,1.6) 2(3.45,0.8) 3(3.45,0) 4(3.45,-0.8) 5(3.45,-1.6)
  rect 2.489x2.007 smd: 6(-2.15,-4.45) 7(3.35,-4.45) 8(3.35,4.45) 9(-2.15,4.45)
CON_SMVT_60POS_QSH_SAMTEC
  round 0.025 hole 1.194 unplated: (-10.063,2.667) (10.06,2.667)
  rect 0.279x2.286 smd: 1(-7.252,-2.865) 2(-7.252,2.865) 3(-6.752,-2.865) 4(-6.752,2.865) 5(-6.252,-2.865) 6(-6.252,2.865) 7(-5.752,-2.865) 8(-5.752,2.865) 9(-5.252,-2.865) 10(-5.252,2.865) 11(-4.752,-2.865) 12(-4.752,2.865) 13(-4.252,-2.865) 14(-4.252,2.865) 15(-3.752,-2.865) 16(-3.752,2.865) 17(-3.252,-2.865) 18(-3.252,2.865) 19(-2.752,-2.865) 20(-2.752,2.865) 21(-2.252,-2.865) 22(-2.252,2.865) 23(-1.752,-2.865) 24(-1.752,2.865) 25(-1.252,-2.865) 26(-1.252,2.865) 27(-0.752,-2.865) 28(-0.752,2.865) 29(-0.252,-2.865) 30(-0.252,2.865) 31(0.248,-2.865) 32(0.248,2.865) 33(0.748,-2.865) 34(0.748,2.865) 35(1.248,-2.865) 36(1.248,2.865) 37(1.748,-2.865) 38(1.748,2.865) 39(2.248,-2.865) 40(2.248,2.865) 41(2.748,-2.865) 42(2.748,2.865) 43(3.248,-2.865) 44(3.248,2.865) 45(3.748,-2.865) 46(3.748,2.865) 47(4.248,-2.865) 48(4.248,2.865) 49(4.748,-2.865) 50(4.748,2.865) 51(5.248,-2.865) 52(5.248,2.865) 53(5.748,-2.865) 54(5.748,2.865) 55(6.248,-2.865) 56(6.248,2.865) 57(6.748,-2.865) 58(6.748,2.865) 59(7.248,-2.865) 60(7.248,2.865)
  rect 2.54x0.432 smd: 61(8.064,0) 64(-8.064,0)
  rect 4.699x0.432 smd: 62(3.175,0) 63(-3.175,0)
CON_SMVT_120POS_QSH_SAMTEC_RT1
  round 4.978 hole 3.962 unplated: (-24.332,0) (24.332,0)
  round 0.635 hole 1.016 unplated: (-20.06,2.67) (20.07,2.67)
  rect 0.279x2.261 smd: 1(-17.25,-2.87) 2(-17.25,2.87) 3(-16.75,-2.87) 4(-16.75,2.87) 5(-16.25,-2.87) 6(-16.25,2.87) 7(-15.75,-2.87) 8(-15.75,2.87) 9(-15.25,-2.87) 10(-15.25,2.87) 11(-14.75,-2.87) 12(-14.75,2.87) 13(-14.25,-2.87) 14(-14.25,2.87) 15(-13.75,-2.87) 16(-13.75,2.87) 17(-13.25,-2.87) 18(-13.25,2.87) 19(-12.75,-2.87) 20(-12.75,2.87) 21(-12.25,-2.87) 22(-12.25,2.87) 23(-11.75,-2.87) 24(-11.75,2.87) 25(-11.25,-2.87) 26(-11.25,2.87) 27(-10.75,-2.87) 28(-10.75,2.87) 29(-10.25,-2.87) 30(-10.25,2.87) 31(-9.75,-2.87) 32(-9.75,2.87) 33(-9.25,-2.87) 34(-9.25,2.87) 35(-8.75,-2.87) 36(-8.75,2.87) 37(-8.25,-2.87) 38(-8.25,2.87) 39(-7.75,-2.87) 40(-7.75,2.87) 41(-7.25,-2.87) 42(-7.25,2.87) 43(-6.75,-2.87) 44(-6.75,2.87) 45(-6.25,-2.87) 46(-6.25,2.87) 47(-5.75,-2.87) 48(-5.75,2.87) 49(-5.25,-2.87) 50(-5.25,2.87) 51(-4.75,-2.87) 52(-4.75,2.87) 53(-4.25,-2.87) 54(-4.25,2.87) 55(-3.75,-2.87) 56(-3.75,2.87) 57(-3.25,-2.87) 58(-3.25,2.87) 59(-2.75,-2.87) 60(-2.75,2.87) 61(2.75,-2.87) 62(2.75,2.87) 63(3.25,-2.87) 64(3.25,2.87) 65(3.75,-2.87) 66(3.75,2.87) 67(4.25,-2.87) 68(4.25,2.87) 69(4.75,-2.87) 70(4.75,2.87) 71(5.25,-2.87) 72(5.25,2.87) 73(5.75,-2.87) 74(5.75,2.87) 75(6.25,-2.87) 76(6.25,2.87) 77(6.75,-2.87) 78(6.75,2.87) 79(7.25,-2.87) 80(7.25,2.87) 81(7.75,-2.87) 82(7.75,2.87) 83(8.25,-2.87) 84(8.25,2.87) 85(8.75,-2.87) 86(8.75,2.87) 87(9.25,-2.87) 88(9.25,2.87) 89(9.75,-2.87) 90(9.75,2.87) 91(10.25,-2.87) 92(10.25,2.87) 93(10.75,-2.87) 94(10.75,2.87) 95(11.25,-2.87) 96(11.25,2.87) 97(11.75,-2.87) 98(11.75,2.87) 99(12.25,-2.87) 100(12.25,2.87) 101(12.75,-2.87) 102(12.75,2.87) 103(13.25,-2.87) 104(13.25,2.87) 105(13.75,-2.87) 106(13.75,2.87) 107(14.25,-2.87) 108(14.25,2.87) 109(14.75,-2.87) 110(14.75,2.87) 111(15.25,-2.87) 112(15.25,2.87) 113(15.75,-2.87) 114(15.75,2.87) 115(16.25,-2.87) 116(16.25,2.87) 117(16.75,-2.87) 118(16.75,2.87) 119(17.25,-2.87) 120(17.25,2.87)
  rect 2.54x0.432 smd: 121(-18.06,0) 124(-1.93,0) 125(1.94,0) 128(18.07,0)
  rect 4.699x0.432 smd: 122(-13.17,0) 123(-6.82,0) 126(6.83,0) 127(13.18,0)
CON_SMVT_180POS_QSH_SAMTEC_RT1
  round 4.978 hole 3.962 unplated: (-4.234,-2.667) (64.447,-2.667)
  round 0.635 hole 1.016 unplated: (0.036,0) (60.175,0)
  rect 0.305x2.286 smd: 1(2.847,-5.532) 2(2.847,0.198) 3(3.348,-5.532) 4(3.348,0.198) 5(3.848,-5.532) 6(3.848,0.198) 7(4.348,-5.532) 8(4.348,0.198) 9(4.849,-5.532) 10(4.849,0.198) 11(5.349,-5.532) 12(5.349,0.198) 13(5.85,-5.532) 14(5.85,0.198) 15(6.35,-5.532) 16(6.35,0.198) 17(6.85,-5.532) 18(6.85,0.198) 19(7.351,-5.532) 20(7.351,0.198) 21(7.851,-5.532) 22(7.851,0.198) 23(8.352,-5.532) 24(8.352,0.198) 25(8.852,-5.532) 26(8.852,0.198) 27(9.352,-5.532) 28(9.352,0.198) 29(9.853,-5.532) 30(9.853,0.198) 31(10.353,-5.532) 32(10.353,0.198) 33(10.853,-5.532) 34(10.853,0.198) 35(11.354,-5.532) 36(11.354,0.198) 37(11.854,-5.532) 38(11.854,0.198) 39(12.355,-5.532) 40(12.355,0.198) 41(12.855,-5.532) 42(12.855,0.198) 43(13.355,-5.532) 44(13.355,0.198) 45(13.856,-5.532) 46(13.856,0.198) 47(14.356,-5.532) 48(14.356,0.198) 49(14.856,-5.532) 50(14.856,0.198) 51(15.357,-5.532) 52(15.357,0.198) 53(15.857,-5.532) 54(15.857,0.198) 55(16.358,-5.532) 56(16.358,0.198) 57(16.858,-5.532) 58(16.858,0.198) 59(17.358,-5.532) 60(17.358,0.198) 61(22.85,-5.532) 62(22.85,0.198) 63(23.35,-5.532) 64(23.35,0.198) 65(23.851,-5.532) 66(23.851,0.198) 67(24.351,-5.532) 68(24.351,0.198) 69(24.851,-5.532) 70(24.851,0.198) 71(25.352,-5.532) 72(25.352,0.198) 73(25.852,-5.532) 74(25.852,0.198) 75(26.352,-5.532) 76(26.352,0.198) 77(26.853,-5.532) 78(26.853,0.198) 79(27.353,-5.532) 80(27.353,0.198) 81(27.854,-5.532) 82(27.854,0.198) 83(28.354,-5.532) 84(28.354,0.198) 85(28.854,-5.532) 86(28.854,0.198) 87(29.355,-5.532) 88(29.355,0.198) 89(29.855,-5.532) 90(29.855,0.198) 91(30.356,-5.532) 92(30.356,0.198) 93(30.856,-5.532) 94(30.856,0.198) 95(31.356,-5.532) 96(31.356,0.198) 97(31.857,-5.532) 98(31.857,0.198) 99(32.357,-5.532) 100(32.357,0.198) 101(32.857,-5.532) 102(32.857,0.198) 103(33.358,-5.532) 104(33.358,0.198) 105(33.858,-5.532) 106(33.858,0.198) 107(34.359,-5.532) 108(34.359,0.198) 109(34.859,-5.532) 110(34.859,0.198) 111(35.359,-5.532) 112(35.359,0.198) 113(35.86,-5.532) 114(35.86,0.198) 115(36.36,-5.532) 116(36.36,0.198) 117(36.86,-5.532) 118(36.86,0.198) 119(37.361,-5.532) 120(37.361,0.198) 121(42.852,-5.532) 122(42.852,0.198) 123(43.353,-5.532) 124(43.353,0.198) 125(43.853,-5.532) 126(43.853,0.198) 127(44.353,-5.532) 128(44.353,0.198) 129(44.854,-5.532) 130(44.854,0.198) 131(45.354,-5.532) 132(45.354,0.198) 133(45.855,-5.532) 134(45.855,0.198) 135(46.355,-5.532) 136(46.355,0.198) 137(46.855,-5.532) 138(46.855,0.198) 139(47.356,-5.532) 140(47.356,0.198) 141(47.856,-5.532) 142(47.856,0.198) 143(48.357,-5.532) 144(48.357,0.198) 145(48.857,-5.532) 146(48.857,0.198) 147(49.357,-5.532) 148(49.357,0.198) 149(49.858,-5.532) 150(49.858,0.198) 151(50.358,-5.532) 152(50.358,0.198) 153(50.858,-5.532) 154(50.858,0.198) 155(51.359,-5.532) 156(51.359,0.198) 157(51.859,-5.532) 158(51.859,0.198) 159(52.36,-5.532) 160(52.36,0.198) 161(52.86,-5.532) 162(52.86,0.198) 163(53.36,-5.532) 164(53.36,0.198) 165(53.861,-5.532) 166(53.861,0.198) 167(54.361,-5.532) 168(54.361,0.198) 169(54.861,-5.532) 170(54.861,0.198) 171(55.362,-5.532) 172(55.362,0.198) 173(55.862,-5.532) 174(55.862,0.198) 175(56.363,-5.532) 176(56.363,0.198) 177(56.863,-5.532) 178(56.863,0.198) 179(57.363,-5.532) 180(57.363,0.198)
  rect 2.54x0.432 smd: 181(2.035,-2.667) 184(18.164,-2.667) 185(22.037,-2.667) 188(38.166,-2.667) 189(42.04,-2.667) 192(58.169,-2.667)
  rect 4.699x0.432 smd: 182(6.924,-2.667) 183(13.274,-2.667) 186(26.927,-2.667) 187(33.277,-2.667) 190(46.929,-2.667) 191(53.279,-2.667)
CON_THRT_POWERJACK_RAPC722
  round 4.318 hole 3.556: 1(0,3.124)
  round 3.81 hole 3.048: 2(0,-3.124) 3(4.801,0.127)
CON_THVT_2X5_100_M
  round 0.254 hole 2.794 unplated: (1.524,8.89) (1.524,-19.05)
  rect 1.651x1.651 hole 0.889: 1(0,0)
  round 1.651 hole 0.889: 2(2.54,0) 3(0,-2.54) 4(2.54,-2.54) 5(0,-5.08) 6(2.54,-5.08) 7(0,-7.62) 8(2.54,-7.62) 9(0,-10.16) 10(2.54,-10.16)
CON_THVT_BANANA_JACK_250DIA
  round 12.7 hole 6.35: 1(0,0)
DIODE_SM_SS3P6L
  rect 1.27x1.397 smd: 1(3.81,1.041) 2(3.81,-1.041)
  rect 4.724x4.801 smd: 3(0,0)
DO-214AB_RECTRON
  rect 1.727x3.175 smd: 1(-3.213,0) 2(3.213,0)
FUSE_SM_NANO
  rect 4.242x3.81 smd: 1(-3.186,0) 2(3.186,0)
HDR_THVT_1X1
  rect 1.473x1.473 hole 0.965: 1(0,0)
HDR_THVT_1X2_100_M
  rect 1.473x1.473 hole 0.965: 1(0,0)
  round 1.473 hole 0.965: 2(0,-2.54)
HDR_THVT_1X3_100_M
  rect 1.473x1.473 hole 0.965: 1(0,0)
  round 1.473 hole 0.965: 2(0,-2.54) 3(0,-5.08)
HDR_THVT_1X3_100_M_KEYED
  rect 1.575x1.575 hole 1.016: 1(0,0)
  round 1.575 hole 1.016: 2(0,-2.54) 3(0,-5.08)
HDR_THVT_2X44_100_F
  rect 1.473x1.473 hole 0.965: 1(0,0)
  round 1.473 hole 0.965: 2(-2.54,0) 3(0,-2.54) 4(-2.54,-2.54) 5(0,-5.08) 6(-2.54,-5.08) 7(0,-7.62) 8(-2.54,-7.62) 9(0,-10.16) 10(-2.54,-10.16) 11(0,-12.7) 12(-2.54,-12.7) 13(0,-15.24) 14(-2.54,-15.24) 15(0,-17.78) 16(-2.54,-17.78) 17(0,-20.32) 18(-2.54,-20.32) 19(0,-22.86) 20(-2.54,-22.86) 21(0,-25.4) 22(-2.54,-25.4) 23(0,-27.94) 24(-2.54,-27.94) 25(0,-30.48) 26(-2.54,-30.48) 27(0,-33.02) 28(-2.54,-33.02) 29(0,-35.56) 30(-2.54,-35.56) 31(0,-38.1) 32(-2.54,-38.1) 33(0,-40.64) 34(-2.54,-40.64) 35(0,-43.18) 36(-2.54,-43.18) 37(0,-45.72) 38(-2.54,-45.72) 39(0,-48.26) 40(-2.54,-48.26) 41(0,-50.8) 42(-2.54,-50.8) 43(0,-53.34) 44(-2.54,-53.34) 45(0,-55.88) 46(-2.54,-55.88) 47(0,-58.42) 48(-2.54,-58.42) 49(0,-60.96) 50(-2.54,-60.96) 51(0,-63.5) 52(-2.54,-63.5) 53(0,-66.04) 54(-2.54,-66.04) 55(0,-68.58) 56(-2.54,-68.58) 57(0,-71.12) 58(-2.54,-71.12) 59(0,-73.66) 60(-2.54,-73.66) 61(0,-76.2) 62(-2.54,-76.2) 63(0,-78.74) 64(-2.54,-78.74) 65(0,-81.28) 66(-2.54,-81.28) 67(0,-83.82) 68(-2.54,-83.82) 69(0,-86.36) 70(-2.54,-86.36) 71(0,-88.9) 72(-2.54,-88.9) 73(0,-91.44) 74(-2.54,-91.44) 75(0,-93.98) 76(-2.54,-93.98) 77(0,-96.52) 78(-2.54,-96.52) 79(0,-99.06) 80(-2.54,-99.06) 81(0,-101.6) 82(-2.54,-101.6) 83(0,-104.14) 84(-2.54,-104.14) 85(0,-106.68) 86(-2.54,-106.68) 87(0,-109.22) 88(-2.54,-109.22)
HTSSOP_14_201X177_26_PWRPAD
  rect 1.524x0.406 smd: 1(-2.825,1.95) 2(-2.825,1.3) 3(-2.825,0.65) 4(-2.825,0) 5(-2.825,-0.65) 6(-2.825,-1.3) 7(-2.825,-1.95) 8(2.825,-1.95) 9(2.825,-1.3) 10(2.825,-0.65) 11(2.825,0) 12(2.825,0.65) 13(2.825,1.3) 14(2.825,1.95)
  rect 2.997x5.004 smd: 15(0,0)
IND_0805
  rect 1.016x1.778 smd: 1(-0.889,0) 2(0.889,0)
IND_SM_7447789002
  rect 1.702x2.007 smd: 1(0,-3.003) 2(0,3.003)
IND_SM_MSS1048
  rect 1.778x3.556 smd: 1(-4.686,0) 2(4.712,0)
LED_0805
  rect 1.422x1.524 smd: 1(-1.143,0) 2(1.143,0)
LQFP_64_402X402_20
  round 1.016 smd: (-6.35,6.35) (6.35,-6.35)
  rect 2.032x0.33 smd: 1(-5.625,3.75) 2(-5.625,3.25) 3(-5.625,2.75) 4(-5.625,2.25) 5(-5.625,1.75) 6(-5.625,1.25) 7(-5.625,0.75) 8(-5.625,0.25) 9(-5.625,-0.25) 10(-5.625,-0.75) 11(-5.625,-1.25) 12(-5.625,-1.75) 13(-5.625,-2.25) 14(-5.625,-2.75) 15(-5.625,-3.25) 16(-5.625,-3.75) 33(5.625,-3.75) 34(5.625,-3.25) 35(5.625,-2.75) 36(5.625,-2.25) 37(5.625,-1.75) 38(5.625,-1.25) 39(5.625,-0.75) 40(5.625,-0.25) 41(5.625,0.25) 42(5.625,0.75) 43(5.625,1.25) 44(5.625,1.75) 45(5.625,2.25) 46(5.625,2.75) 47(5.625,3.25) 48(5.625,3.75)
  rect 0.33x2.032 smd: 17(-3.75,-5.625) 18(-3.25,-5.625) 19(-2.75,-5.625) 20(-2.25,-5.625) 21(-1.75,-5.625) 22(-1.25,-5.625) 23(-0.75,-5.625) 24(-0.25,-5.625) 25(0.25,-5.625) 26(0.75,-5.625) 27(1.25,-5.625) 28(1.75,-5.625) 29(2.25,-5.625) 30(2.75,-5.625) 31(3.25,-5.625) 32(3.75,-5.625) 49(3.75,5.625) 50(3.25,5.625) 51(2.75,5.625) 52(2.25,5.625) 53(1.75,5.625) 54(1.25,5.625) 55(0.75,5.625) 56(0.25,5.625) 57(-0.25,5.625) 58(-0.75,5.625) 59(-1.25,5.625) 60(-1.75,5.625) 61(-2.25,5.625) 62(-2.75,5.625) 63(-3.25,5.625) 64(-3.75,5.625)
OSC-3X5MM
  rect 1.4x1.6 smd: 1(-1.27,-1.4) 2(1.27,-1.4) 3(1.27,1.4) 4(-1.27,1.4)
QFN_14_144X144_PWRPAD
  oval 0.838x0.279 smd: 1(-1.719,-0.75) 7(1.719,-0.75) 8(1.719,0.75) 14(-1.719,0.75)
  oval 0.279x0.838 smd: 2(-1,-1.719) 3(-0.5,-1.719) 4(0,-1.719) 5(0.5,-1.719) 6(1,-1.719) 9(1,1.719) 10(0.5,1.719) 11(0,1.719) 12(-0.5,1.719) 13(-1,1.719)
  rect 2.032x2.032 smd: 15(0,0)
QFN_20_203X203_26_PWRPAD
  oval 1.016x0.356 smd: 1(-2.408,1.3) 2(-2.408,0.65) 3(-2.408,0) 4(-2.408,-0.65) 5(-2.408,-1.3) 11(2.408,-1.3) 12(2.408,-0.65) 13(2.408,0) 14(2.408,0.65) 15(2.408,1.3)
  oval 0.356x1.016 smd: 6(-1.3,-2.408) 7(-0.65,-2.408) 8(0,-2.408) 9(0.65,-2.408) 10(1.3,-2.408) 16(1.3,2.408) 17(0.65,2.408) 18(0,2.408) 19(-0.65,2.408) 20(-1.3,2.408)
  rect 3.15x3.15 smd: 21(0,0)
RA-VEX-0402-8
  rect 0.4x0.7 smd: 1(-0.75,-0.55) 4(0.75,-0.55) 5(0.75,0.55) 8(-0.75,0.55)
  rect 0.3x0.7 smd: 2(-0.25,-0.55) 3(0.25,-0.55) 6(0.25,0.55) 7(-0.25,0.55)
SMA_THVT_312X312
  round 2.337 hole 1.575: 1(0,0)
  round 2.464 hole 1.702: 2(-2.54,2.54) 3(2.54,2.54) 4(2.54,-2.54) 5(-2.54,-2.54)
SMD_JUMPER_1X3
  rect 1.27x1.27 smd: 1(-1.422,0) 2(0,0) 3(1.422,0)
SOCKET-SO-DIMM200
  round 0.635 hole 1.6 unplated: (-33.4,0)
  rect 4.5x4.6 smd: (-32.55,12) (32.55,12)
  round 0.635 hole 1.118 unplated: (33.4,0)
  rect 0.35x2 smd: 1(-31.65,-4.1) 2(-31.35,4.1) 3(-31.05,-4.1) 4(-30.75,4.1) 5(-30.45,-4.1) 6(-30.15,4.1) 7(-29.85,-4.1) 8(-29.55,4.1) 9(-29.25,-4.1) 10(-28.95,4.1) 11(-28.65,-4.1) 12(-28.35,4.1) 13(-28.05,-4.1) 14(-27.75,4.1) 15(-27.45,-4.1) 16(-27.15,4.1) 17(-26.85,-4.1) 18(-26.55,4.1) 19(-26.25,-4.1) 20(-25.95,4.1) 21(-25.65,-4.1) 22(-25.35,4.1) 23(-25.05,-4.1) 24(-24.75,4.1) 25(-24.45,-4.1) 26(-24.15,4.1) 27(-23.85,-4.1) 28(-23.55,4.1) 29(-23.25,-4.1) 30(-22.95,4.1) 31(-22.65,-4.1) 32(-22.35,4.1) 33(-22.05,-4.1) 34(-21.75,4.1) 35(-21.45,-4.1) 36(-21.15,4.1) 37(-20.85,-4.1) 38(-20.55,4.1) 39(-20.25,-4.1) 40(-19.95,4.1) 41(-16.05,-4.1) 42(-15.75,4.1) 43(-15.45,-4.1) 44(-15.15,4.1) 45(-14.85,-4.1) 46(-14.55,4.1) 47(-14.25,-4.1) 48(-13.95,4.1) 49(-13.65,-4.1) 50(-13.35,4.1) 51(-13.05,-4.1) 52(-12.75,4.1) 53(-12.45,-4.1) 54(-12.15,4.1) 55(-11.85,-4.1) 56(-11.55,4.1) 57(-11.25,-4.1) 58(-10.95,4.1) 59(-10.65,-4.1) 60(-10.35,4.1) 61(-10.05,-4.1) 62(-9.75,4.1) 63(-9.45,-4.1) 64(-9.15,4.1) 65(-8.85,-4.1) 66(-8.55,4.1) 67(-8.25,-4.1) 68(-7.95,4.1) 69(-7.65,-4.1) 70(-7.35,4.1) 71(-7.05,-4.1) 72(-6.75,4.1) 73(-6.45,-4.1) 74(-6.15,4.1) 75(-5.85,-4.1) 76(-5.55,4.1) 77(-5.25,-4.1) 78(-4.95,4.1) 79(-4.65,-4.1) 80(-4.35,4.1) 81(-4.05,-4.1) 82(-3.75,4.1) 83(-3.45,-4.1) 84(-3.15,4.1) 85(-2.85,-4.1) 86(-2.55,4.1) 87(-2.25,-4.1) 88(-1.95,4.1) 89(-1.65,-4.1) 90(-1.35,4.1) 91(-1.05,-4.1) 92(-0.75,4.1) 93(-0.45,-4.1) 94(-0.15,4.1) 95(0.15,-4.1) 96(0.45,4.1) 97(0.75,-4.1) 98(1.05,4.1) 99(1.35,-4.1) 100(1.65,4.1) 101(1.95,-4.1) 102(2.25,4.1) 103(2.55,-4.1) 104(2.85,4.1) 105(3.15,-4.1) 106(3.45,4.1) 107(3.75,-4.1) 108(4.05,4.1) 109(4.35,-4.1) 110(4.65,4.1) 111(4.95,-4.1) 112(5.25,4.1) 113(5.55,-4.1) 114(5.85,4.1) 115(6.15,-4.1) 116(6.45,4.1) 117(6.75,-4.1) 118(7.05,4.1) 119(7.35,-4.1) 120(7.65,4.1) 121(7.95,-4.1) 122(8.25,4.1) 123(8.55,-4.1) 124(8.85,4.1) 125(9.15,-4.1) 126(9.45,4.1) 127(9.75,-4.1) 128(10.05,4.1) 129(10.35,-4.1) 130(10.65,4.1) 131(10.95,-4.1) 132(11.25,4.1) 133(11.55,-4.1) 134(11.85,4.1) 135(12.15,-4.1) 136(12.45,4.1) 137(12.75,-4.1) 138(13.05,4.1) 139(13.35,-4.1) 140(13.65,4.1) 141(13.95,-4.1) 142(14.25,4.1) 143(14.55,-4.1) 144(14.85,4.1) 145(15.15,-4.1) 146(15.45,4.1) 147(15.75,-4.1) 148(16.05,4.1) 149(16.35,-4.1) 150(16.65,4.1) 151(16.95,-4.1) 152(17.25,4.1) 153(17.55,-4.1) 154(17.85,4.1) 155(18.15,-4.1) 156(18.45,4.1) 157(18.75,-4.1) 158(19.05,4.1) 159(19.35,-4.1) 160(19.65,4.1) 161(19.95,-4.1) 162(20.25,4.1) 163(20.55,-4.1) 164(20.85,4.1) 165(21.15,-4.1) 166(21.45,4.1) 167(21.75,-4.1) 168(22.05,4.1) 169(22.35,-4.1) 170(22.65,4.1) 171(22.95,-4.1) 172(23.25,4.1) 173(23.55,-4.1) 174(23.85,4.1) 175(24.15,-4.1) 176(24.45,4.1) 177(24.75,-4.1) 178(25.05,4.1) 179(25.35,-4.1) 180(25.65,4.1) 181(25.95,-4.1) 182(26.25,4.1) 183(26.55,-4.1) 184(26.85,4.1) 185(27.15,-4.1) 186(27.45,4.1) 187(27.75,-4.1) 188(28.05,4.1) 189(28.35,-4.1) 190(28.65,4.1) 191(28.95,-4.1) 192(29.25,4.1) 193(29.55,-4.1) 194(29.85,4.1) 195(30.15,-4.1) 196(30.45,4.1) 197(30.75,-4.1) 198(31.05,4.1) 199(31.35,-4.1) 200(31.65,4.1)
SOIC-8
  rect 0.6x1.6 smd: 1(-1.905,-2.65) 2(-0.635,-2.65) 3(0.635,-2.65) 4(1.905,-2.65) 5(1.905,2.65) 6(0.635,2.65) 7(-0.635,2.65) 8(-1.905,2.65)
SOIC_10_122X122_50_PWRPAD
  rect 1.651x0.305 smd: 1(-2.145,1) 2(-2.145,0.5) 3(-2.145,0) 4(-2.145,-0.5) 5(-2.145,-1) 6(2.145,-1) 7(2.145,-0.5) 8(2.145,0) 9(2.145,0.5) 10(2.145,1)
  rect 1.575x1.88 smd: 11(0,0)
SOIC_16_410X299_50
  round 1.016 smd: (0,0)
  rect 2.286x0.66 smd: 1(-4.566,4.445) 2(-4.566,3.175) 3(-4.566,1.905) 4(-4.566,0.635) 5(-4.566,-0.635) 6(-4.566,-1.905) 7(-4.566,-3.175) 8(-4.566,-4.445) 9(4.566,-4.445) 10(4.566,-3.175) 11(4.566,-1.905) 12(4.566,-0.635) 13(4.566,0.635) 14(4.566,1.905) 15(4.566,3.175) 16(4.566,4.445)
SON_10_124X124_PWRPAD
  oval 0.838x0.279 smd: 1(-1.475,0.975) 2(-1.475,0.475) 3(-1.475,-0.025) 4(-1.475,-0.525) 5(-1.475,-1.025) 6(1.475,-1.025) 7(1.475,-0.525) 8(1.475,-0.025) 9(1.475,0.475) 10(1.475,0.975)
  rect 1.651x2.388 smd: 11(0,0)
  rect 0.279x0.711 smd: 12(-0.25,1.526) 13(0.25,1.526) 14(-0.25,-1.526) 15(0.25,-1.526)
SOP_5_118X67_37
  rect 0.762x1.524 smd: 1(-0.95,-1.125) 2(0,-1.125) 3(0.95,-1.125) 4(0.95,1.125) 5(-0.95,1.125)
SOT_5_118X67_57
  rect 0.61x1.524 smd: 1(-0.95,-1.75) 2(0,-1.75) 3(0.95,-1.75) 4(0.95,1.75) 5(-0.95,1.75)
SOT_323
  rect 0.787x0.889 smd: 1(-0.66,-0.953) 2(0.66,-0.953) 3(0,0.953)
SW-SMD-8
  rect 0.76x1.27 smd: 1(-1.905,-3.81) 2(-0.635,-3.81) 3(0.635,-3.81) 4(1.905,-3.81) 5(1.905,3.81) 6(0.635,3.81) 7(-0.635,3.81) 8(-1.905,3.81)
SW_SMVT_SPST_4
  rect 3.175x1.6 smd: 1(-2.603,1.994) 2(2.603,1.994) 3(-2.603,-1.994) 4(2.603,-1.994)
SW_THVT_4PDT_SLIDE_12
  round 2.032 hole 1.27: (-1.55,-11.6) (4.05,1.6)
  rect 1.575x1.575 hole 0.813: 1(0,0)
  round 1.575 hole 0.813: 2(0,-2) 3(0,-4) 4(0,-6) 5(0,-8) 6(0,-10) 7(2.5,0) 8(2.5,-2) 9(2.5,-4) 10(2.5,-6) 11(2.5,-8) 12(2.5,-10)
TANT_A
  rect 1.524x1.397 smd: 1(-1.283,0) 2(1.283,0)
TANT_D
  rect 2.108x2.591 smd: 1(-2.896,0) 2(2.896,0)
TANT_E
  rect 2.108x2.591 smd: 1(-2.997,0) 2(2.997,0)
TP_THVT_060_RND
  round 1.524 hole 1.016: 1(0,0)
TSSOP_20_260X177_26
  rect 1.295x0.381 smd: 1(-2.921,2.931) 2(-2.921,2.281) 3(-2.921,1.631) 4(-2.921,0.981) 5(-2.921,0.331) 6(-2.921,-0.319) 7(-2.921,-0.969) 8(-2.921,-1.619) 9(-2.921,-2.269) 10(-2.921,-2.919) 11(2.929,-2.919) 12(2.929,-2.269) 13(2.929,-1.619) 14(2.929,-0.969) 15(2.929,-0.319) 16(2.929,0.331) 17(2.929,0.981) 18(2.929,1.631) 19(2.929,2.281) 20(2.929,2.931)
unnamed
  round 2.54 hole 3.175 unplated: (0,0)
VSSOP_8_83X94_0P5MM
  rect 0.8x0.3 smd: 1(-1.55,0.75) 2(-1.55,0.25) 3(-1.55,-0.25) 4(-1.55,-0.75) 5(1.55,-0.75) 6(1.55,-0.25) 7(1.55,0.25) 8(1.55,0.75)
XTAL_4_SM_130X102
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)

## Nets
0.9V: C53.2 C54.1 C144.1(ANODE) C145.1 C146.1 C147.1 C148.1 C149.1 C150.1 C151.1 C152.1 C153.1 C154.1 C155.1 C156.1 C158.2 C159.2 C160.2 C161.2 C163.1 C164.2 C165.2 C166.A C166.B C167.A C167.B C168.A C168.B C169.A C169.B C170.A C170.B C171.A C171.B C172.A C172.B C173.A C173.B C174.A C174.B C175.A C175.B C176.A C176.B C177.A C177.B C178.A C178.B C179.1 C180.1 C181.1 C182.1 C183.1 C184.1 C185.1 C187.1 C188.1 C190.1 C191.1 C192.1 C193.1 C194.1 C195.1 C196.1 C197.1 C198.1 C199.1 C200.1 C201.1 C202.1 C203.1 C204.1 C205.1 C206.1 C207.1 C208.1 C209.1 C210.1 C211.1 C212.1 C213.1 C214.1 C215.1 C216.1 C217.1 C219.1 C220.1 C221.1 C222.1 C223.1 C225.1 C226.1 C228.1 C229.1 C230.1 C231.1 C232.1 C260.1 C261.1 C262.1 C263.1 FB5.1 L6.2 R24.2 TP16.1(TP) U5.AA15(VCC#AA15) U5.AA17(VCC#AA17) U5.AA19(VCC#AA19) U5.AA21(VCC#AA21) U5.AE25(VREFB2AN0) U5.AG14(VREFB4AN0) U5.AG20(VREFB3AN0) U5.AH19(VREFB3CN0) U5.AJ16(VREFB4CN0) U5.P14(VCC#P14) U5.P16(VCC#P16) U5.P18(VCC#P18) U5.P20(VCC#P20) U5.R15(VCC#R15) U5.R17(VCC#R17) U5.R19(VCC#R19) U5.R21(VCC#R21) U5.T8(VCC#T8) U5.T14(VCC#T14) U5.T16(VCC#T16) U5.T18(VCC#T18) U5.T20(VCC#T20) U5.T27(VCC#T27) U5.U8(VCC#U8) U5.U15(VCC#U15) U5.U17(VCC#U17) U5.U19(VCC#U19) U5.U21(VCC#U21) U5.U27(VCC#U27) U5.V9(VCCHIP_R#V9) U5.V14(VCC#V14) U5.V16(VCC#V16) U5.V18(VCC#V18) U5.V20(VCC#V20) U5.V26(VCCHIP_L#V26) U5.W8(VCC#W8) U5.W9(VCCHIP_R#W9) U5.W15(VCC#W15) U5.W17(VCC#W17) U5.W19(VCC#W19) U5.W21(VCC#W21) U5.W26(VCCHIP_L#W26) U5.W27(VCC#W27) U5.Y8(VCC#Y8) U5.Y9(VCCHIP_R#Y9) U5.Y14(VCC#Y14) U5.Y16(VCC#Y16) U5.Y18(VCC#Y18) U5.Y20(VCC#Y20) U5.Y26(VCCHIP_L#Y26) U5.Y27(VCC#Y27)
0.9V_DDR: C71.1 CN1.1 CN1.2 CN1.3 CN1.4 CN4.1 CN4.2 CN4.3 CN4.4 CN7.1 CN7.2 CN7.3 CN7.4 CN10.1 CN10.2 CN10.3 CN10.4 RN8.1 RN8.2 RN8.3 RN8.4 RN9.1 RN9.2 RN9.3 RN9.4 RN12.1 RN12.2 RN12.3 RN12.4 RN13.1 RN13.2 RN13.3 RN13.4 RN18.1 RN18.2 RN18.3 RN18.4 RN19.1 RN19.2 RN19.3 RN19.4 RN24.1 RN24.2 RN24.3 RN24.4 U11.3(VTT) U11.5(VTTSNS)
0.9V_VREF: C34.1 C75.2 J6.1(VREF) U11.6(VTTREF)
1.1V: C47.2 C101.1 C102.1 C103.2 C104.2 C105.2 C106.2 C107.2 C108.2 C233.2 C234.2 C235.2 C236.2 C237.2 C238.2 C239.2 C240.2 C241.2 C242.2 R19.2 TP14.1(TP) U5.AA5(VCCT_R#AA5) U5.AA30(VCCT_L#AA30) U5.N5(VCCR_R#N5) U5.N30(VCCR_L#N30) U5.R5(VCCT_R#R5) U5.R7(VCCL_GXBR1#R7) U5.R28(VCCL_GXBL1#R28) U5.R30(VCCT_L#R30) U5.T7(VCCL_GXBR1#T7) U5.T28(VCCL_GXBL1#T28) U5.V7(VCCL_GXBR0#V7) U5.V28(VCCL_GXBL0#V28) U5.W5(VCCR_R#W5) U5.W7(VCCL_GXBR0#W7) U5.W28(VCCL_GXBL0#W28) U5.W30(VCCR_L#W30) U7.1(OUT) U7.18(OUT3) U7.19(OUT2) U7.20(OUT1)
1.5V: C62.1 C109.2 C110.2 C111.2 C112.2 C113.2 FB6.1 L7.2 R26.2 TP17.1(TP) U5.T6(VCCH_GXBR1) U5.T29(VCCH_GXBL1) U5.W6(VCCH_GXBR0) U5.W29(VCCH_GXBL0) U9.1(VO)
1.8V: C22.1 C23.1 C24.1 C25.1 C26.1 C27.1 C28.1 C29.1 C30.1 C31.1 C32.1 C33.1 C35.1 C36.1 C37.1 C38.1 C39.1 C65.2 C66.1 C72.1 C114.1 C115.1 C116.1 C117.1 C118.2 C119.2 C120.2 C121.2 C122.2 C123.2 C265.2 C266.2 C267.2 C268.2 C269.2 C270.2 C271.2 C272.2 C273.2 J6.81(VDD#81) J6.82(VDD#82) J6.87(VDD#87) J6.88(VDD#88) J6.95(VDD#95) J6.96(VDD#96) J6.103(VDD#103) J6.104(VDD#104) J6.111(VDD#111) J6.112(VDD#112) J6.117(VDD#117) J6.118(VDD#118) J6.199(VDDSPD) J8.1 JP3.1(PIN1) JP4.1(PIN1) JP8.1(PIN1) L8.2 R9.1 R10.1 R18.1 R32.2 TP18.1(TP) U5.AC23(VCCIO2A#AC23) U5.AE26(VCCIO2A#AE26) U5.AH15(VCCIO4A#AH15) U5.AH21(VCCIO3A#AH21) U5.AH27(VCCIO2A#AH27) U5.AJ11(VCCIO4A#AJ11) U5.AJ17(VCCIO4C#AJ17) U5.AJ24(VCCIO3A#AJ24) U5.AK18(VCCIO3C#AK18) U5.AM9(VCCIO4A#AM9) U5.AM12(VCCIO4A#AM12) U5.AM24(VCCIO3A#AM24) U5.AM27(VCCIO3A#AM27) U5.AP16(VCCIO4C#AP16) U5.AP19(VCCIO3C#AP19) U11.1(VDDQSNS) U11.2(VLDOIN)
1.8V_USB: C3.1 C4.1 C13.1 C14.1 C15.1 U3.12(VCORE#12) U3.37(VCORE#37) U3.49(VREGOUT) U3.64(VCORE#64)
2.5V: C48.2 C87.2 C88.1 C124.1 C125.2 C126.2 C127.2 C128.2 C129.2 C130.2 C131.2 C132.2 C133.2 C134.1 C135.2 C139.1 C141.2 C143.2 C157.2 C243.2 C244.2 C245.2 C246.2 C247.2 C248.2 C249.2 C274.2 C275.2 C276.2 C277.2 C278.2 C279.2 C280.2 C281.2 C282.2 C283.2 C284.2 C285.2 C286.2 C287.2 C288.2 C289.2 C290.2 FB4.1 L10.2 R22.1 R40.2 TP20.1(TP) U5.AA13(VCCPD5A) U5.AB14(VCCPD4A) U5.AB16(VCCPD4C) U5.AB18(VCCPD3C) U5.AB20(VCCPD3A) U5.AB22(VCCPD2A) U5.AB24(VCCIO2C#AB24) U5.AC8(VCCIO5C#AC8) U5.AC27(VCCIO2C#AC27) U5.AE11(VCCIO5A#AE11) U5.AF22(VCCAUX#AF22) U5.AG17(VCC_CLKIN4C) U5.AH6(VCCIO5A#AH6) U5.AH9(VCCIO5A#AH9) U5.AJ18(VCC_CLKIN3C) U5.AK9(VCCAUX#AK9) U5.F8(VCCIO6A#F8) U5.F18(VCC_CLKIN8C) U5.F27(VCCIO1A#F27) U5.G10(VCCAUX#G10) U5.H17(VCC_CLKIN7C) U5.J6(VCCIO6A#J6) U5.J11(VCCIO6A#J11) U5.J22(VCCAUX#J22) U5.J24(VCCIO1A#J24) U5.M9(VCCIO6C#M9) U5.M27(VCCIO1C#M27) U5.N13(VCCPD6A) U5.N15(VCCPD7A) U5.N24(VCCIO1A#N24) U5.P22(VCCPD1A) U5.T12(VCCIO6C#T12) U5.T22(VCCPD1C) U5.T23(VCCIO1C#T23) U5.U13(VCCPD6C) U5.V22(VCCPD2C) U5.W13(VCCPD5C) U5.Y11(VCCIO5C#Y11) U7.5(IN1) U7.6(IN2) U7.7(IN3) U7.8(IN4)
3.0V: C94.1 C95.1 C100.1 C136.2 C137.2 C138.2 C140.2 C162.2 C186.2 C189.2 C218.2 C224.2 C227.1 C250.2 C251.2 C252.2 C253.2 C254.2 C255.2 C257.2 C258.2 C259.2 DN1.3 DN2.3 J13.4 JP3.3(PIN3) JP4.3(PIN3) JP8.3(PIN3) L11.2 R48.2 R49.1 R50.1 R51.1 R52.2 R53.1 R137.1 R140.1 R141.1 R143.1 SJP3.1(PIN1) TP19.1(TP) U5.A19(VCCIO8C#A19) U5.AH10(VCCPGM#AH10) U5.AK26(VCCPGM#AK26) U5.C8(VCCIO7A#C8) U5.C11(VCCIO7A#C11) U5.C24(VCCIO8A#C24) U5.C27(VCCIO8A#C27) U5.C32(TRST) U5.E18(VCCIO8C#E18) U5.F12(VCCIO7A#F12) U5.F24(VCCIO8A#F24) U5.G15(VCCIO7A#G15) U5.G21(VCCIO8A#G21) U5.N17(VCCPD7C) U5.N19(VCCPD8C) U5.N21(VCCPD8A) U15.1(VO) U19.1(VCC#1) U19.2(VCC#2) U19.9(VCC#9)
3.3V: C45.1 C85.1 C334.2 J10.1 L4.1 L9.2 R15.1 R38.2 R68.1 R69.1 R70.1 R71.1 R72.1 R73.1 R74.1 R75.1 R80.1 R81.1 R82.1 R83.1 R84.1 R85.1 R86.1 R87.1 R88.1 R125.1 TP21.1(TP) U12.1(VO) U18.1(IN1) U18.2(IN2) Y2.1(EN) Y2.4(VCC)
3.3V_CLKB: C40.1 C41.1 L4.2 U6.1(VCC)
3.3V_USB: C7.1 C9.1 C16.1 C17.1 C18.1 C19.1 FB1.1 FB2.1 R5.1 R6.1 R7.1 U2.5(OUT) U3.20(VCCIO#20) U3.31(VCCIO#31) U3.42(VCCIO#42) U3.50(VREGIN) U3.56(VCCIO#56) U4.6(ORG) U4.8(VCC) U16.19(VCCB) U17.19(VCCB)
5V_IN: C50.2 C52.1 C55.1 C56.1 C67.1 C68.1 C73.1 C76.2 C77.1 C78.1 C79.1 C80.1 C81.1 C92.1 C96.1 C294.2 C335.2 C349.1 C350.1 C355.1 F1.2 L12.1 R29.1 R33.1 R43.1 R77.1 R79.1 R113.2 R114.2 R120.1 R154.2 R155.2 U1.8(VCC) U7.10(BIAS) U8.4(PVIN#4) U8.5(PVIN#5) U8.6(VIN) U9.13(VIN) U9.14(VCC) U10.4(PVIN#4) U10.5(PVIN#5) U10.6(VIN) U11.10(VIN) U12.13(VIN) U12.14(VCC) U13.4(PVIN#4) U13.5(PVIN#5) U13.6(VIN) U14.8(VCC) U15.13(VIN) U15.14(VCC) U18.4(BIAS) U20.3(VIN)
5V_USB: C8.1 L3.2 U2.1(IN)
6.0V_OUT: C296.1 D11.3 F2.1 R145.1
GND: C1.2 C2.2 C3.2 C4.2 C5.2 C6.2 C7.2 C8.2 C9.2 C10.2 C11.2 C12.2 C13.2 C14.2 C15.2 C16.2 C17.2 C18.2 C19.2 C20.2 C21.2 C22.2 C23.2 C24.2 C25.2 C26.2 C27.2 C28.2 C29.2 C30.2 C31.2 C32.2 C33.2 C34.2 C35.2 C36.2 C37.2 C38.2 C39.2 C40.2 C41.2 C45.2 C47.1 C48.1 C49.1 C50.1 C52.2 C53.1 C54.2 C55.2 C56.2 C57.2 C58.2 C60.1 C61.1 C62.2 C63.2 C65.1 C66.2 C67.2 C68.2 C69.2 C70.2 C71.2 C72.2 C73.2 C74.2 C75.1 C76.1 C77.2 C78.2 C79.2 C80.2 C81.2 C83.1 C84.1 C85.2 C87.1 C88.2 C90.2 C91.2 C92.2 C93.2 C94.2 C95.2 C96.2 C98.1 C99.1 C100.2 C101.2 C102.2 C103.1 C104.1 C105.1 C106.1 C107.1 C108.1 C109.1 C110.1 C111.1 C112.1 C113.1 C114.2 C115.2 C116.2 C117.2 C118.1 C119.1 C120.1 C121.1 C122.1 C123.1 C124.2 C125.1 C126.1 C127.1 C128.1 C129.1 C130.1 C131.1 C132.1 C133.1 C134.2 C135.1 C136.1 C137.1 C138.1 C139.2 C140.1 C141.1 C143.1 C144.2(CATHODE) C145.2 C146.2 C147.2 C148.2 C149.2 C150.2 C151.2 C152.2 C153.2 C154.2 C155.2 C156.2 C157.1 C158.1 C159.1 C160.1 C161.1 C162.1 C163.2 C164.1 C165.1 C166.G1 C166.G2 C167.G1 C167.G2 C168.G1 C168.G2 C169.G1 C169.G2 C170.G1 C170.G2 C171.G1 C171.G2 C172.G1 C172.G2 C173.G1 C173.G2 C174.G1 C174.G2 C175.G1 C175.G2 C176.G1 C176.G2 C177.G1 C177.G2 C178.G1 C178.G2 C179.2 C180.2 C181.2 C182.2 C183.2 C184.2 C185.2 C186.1 C187.2 C188.2 C189.1 C190.2 C191.2 C192.2 C193.2 C194.2 C195.2 C196.2 C197.2 C198.2 C199.2 C200.2 C201.2 C202.2 C203.2 C204.2 C205.2 C206.2 C207.2 C208.2 C209.2 C210.2 C211.2 C212.2 C213.2 C214.2 C215.2 C216.2 C217.2 C218.1 C219.2 C220.2 C221.2 C222.2 C223.2 C224.1 C225.2 C226.2 C227.2 C228.2 C229.2 C230.2 C231.2 C232.2 C233.1 C234.1 C235.1 C236.1 C237.1 C238.1 C239.1 C240.1 C241.1 C242.1 C243.1 C244.1 C245.1 C246.1 C247.1 C248.1 C249.1 C250.1 C251.1 C252.1 C253.1 C254.1 C255.1 C257.1 C258.1 C259.1 C260.2 C261.2 C262.2 C263.2 C265.1 C266.1 C267.1 C268.1 C269.1 C270.1 C271.1 C272.1 C273.1 C274.1 C275.1 C276.1 C277.1 C278.1 C279.1 C280.1 C281.1 C282.1 C283.1 C284.1 C285.1 C286.1 C287.1 C288.1 C289.1 C290.1 C294.1 C295.2 C296.2 C328.2 C329.2 C330.2 C331.2 C332.2 C333.2 C334.1 C335.1 C336.2 C337.2 C338.2 C339.2 C340.2 C341.2 C342.2 C349.2 C350.2 C351.2 C352.2 C353.2 C354.2 C355.2 CN1.5 CN1.6 CN1.7 CN1.8 CN4.5 CN4.6 CN4.7 CN4.8 CN7.5 CN7.6 CN7.7 CN7.8 CN10.5 CN10.6 CN10.7 CN10.8 D1.2(CATHODE) D10.2(CATHODE) D14.2(ANODE) J1.2 J1.4 J1.6 J1.8 J1.10 J1.12 J1.14 J1.16 J1.18 J1.20 J1.22 J1.24 J1.26 J1.28 J1.30 J1.32 J1.34 J1.36 J1.38 J1.40 J1.42 J1.44 J1.46 J1.48 J1.50 J1.52 J1.54 J1.56 J1.58 J1.60 J1.62 J1.64 J1.66 J1.68 J1.70 J1.72 J1.74 J1.76 J1.78 J1.80 J1.82 J1.84 J1.86 J1.88 J2.1 J2.2 J2.7 J2.8 J2.13 J2.14 J2.19 J2.20 J2.25 J2.26 J2.31 J2.32 J2.37 J2.38 J2.43 J2.44 J2.49 J2.50 J2.55 J2.56 J2.61(GND#61) J2.62(GND#62) J2.63(GND#63) J2.64(GND#64) J3.5 J3.6 J3.11 J3.12 J3.17 J3.18 J3.23 J3.24 J3.29 J3.30 J3.35 J3.36 J3.41 J3.42 J3.47 J3.48 J3.53 J3.54 J3.59 J3.60 J3.61 J3.62 J3.67 J3.68 J3.73 J3.74 J3.79 J3.80 J3.85 J3.86 J3.91 J3.92 J3.97 J3.98 J3.103 J3.104 J3.110 J3.116 J3.121(GND#121) J3.122(GND#122) J3.123(GND#123) J3.124(GND#124) J3.125(GND#125) J3.126(GND#126) J3.127(GND#127) J3.128(GND#128) J4.7 J4.8 J4.9 J4.10 J4.65 J4.66 J4.71 J4.72 J4.77 J4.78 J4.83 J4.84 J4.89 J4.90 J4.95 J4.96 J4.101 J4.102 J4.107 J4.108 J4.113 J4.114 J4.119 J4.120 J4.125 J4.126 J4.131 J4.132 J4.137 J4.138 J4.143 J4.144 J4.149 J4.150 J4.155 J4.156 J4.161 J4.162 J4.167 J4.168 J4.173 J4.174 J4.179 J4.180 J4.181(GND#181) J4.182(GND#182) J4.183(GND#183) J4.184(GND#184) J4.185(GND#185) J4.186(GND#186) J4.187(GND#187) J4.188(GND#188) J4.189(GND#189) J4.190(GND#190) J4.191(GND#191) J4.192(GND#192) J5.5(GND) J5.6(GND1) J5.7(GND2) J5.8(GND3) J5.9(GND4) J6.2(VSS#2) J6.3(VSS#3) J6.8(VSS#8) J6.9(VSS#9) J6.12(VSS#12) J6.15(VSS#15) J6.18(VSS#18) J6.21(VSS#21) J6.24(VSS#24) J6.27(VSS#27) J6.28(VSS#28) J6.33(VSS#33) J6.34(VSS#34) J6.39(VSS#39) J6.40(VSS#40) J6.41(VSS#41) J6.42(VSS#42) J6.47(VSS#47) J6.48(VSS#48) J6.53(VSS#53) J6.54(VSS#54) J6.59(VSS#59) J6.60(VSS#60) J6.65(VSS#65) J6.66(VSS#66) J6.71(VSS#71) J6.72(VSS#72) J6.77(VSS#77) J6.78(VSS#78) J6.121(VSS#121) J6.122(VSS#122) J6.127(VSS#127) J6.128(VSS#128) J6.132(VSS#132) J6.133(VSS#133) J6.138(VSS#138) J6.139(VSS#139) J6.144(VSS#144) J6.145(VSS#145) J6.149(VSS#149) J6.150(VSS#150) J6.155(VSS#155) J6.156(VSS#156) J6.161(VSS#161) J6.162(VSS#162) J6.165(VSS#165) J6.168(VSS#168) J6.171(VSS#171) J6.172(VSS#172) J6.177(VSS#177) J6.178(VSS#178) J6.183(VSS#183) J6.184(VSS#184) J6.187(VSS#187) J6.190(VSS#190) J6.193(VSS#193) J6.196(VSS#196) J6.198(SA0) J6.200(SA1) J7.2(GND#2) J7.3(GND#3) J7.4(GND#4) J7.5(GND#5) J9.1 J11.2(GND#2) J11.3(GND#3) J11.4(GND#4) J11.5(GND#5) J12.2 J12.3 J13.2 J13.10 J14.2(GND#2) J14.3(GND#3) J14.4(GND#4) J14.5(GND#5) J15.2(GND#2) J15.3(GND#3) J15.4(GND#4) J15.5(GND#5) J16.2(GND#2) J16.3(GND#3) J16.4(GND#4) J16.5(GND#5) J17.2(GND#2) J17.3(GND#3) J17.4(GND#4) J17.5(GND#5) J18.2 R4.2 R16.2 R17.1 R21.2 R23.1 R25.1 R28.2 R30.2 R31.1 R35.2 R36.2 R37.1 R39.1 R42.2 R44.2 R45.2 R47.1 R55.1 R89.1 R90.1 R91.2 R92.2 R93.2 R94.2 R95.2 R98.1 R116.1 R133.2 R138.2 R139.2 R142.2 R146.2 R147.2 R148.2 R158.2 SJP1.3(PIN3) SJP2.3(PIN3) SJP3.3(PIN3) SW1.1(A1) SW1.2(A2) SW1.3(A3) SW1.4(A4) SW2.1 SW2.2 SW3.1 SW3.2 SW4.1 SW4.2 SW5.1 SW5.2 SW6.1 SW6.2 SW7.3 SW7.6 SW7.9 SW7.12 TP22.1(TP) TP23.1(TP) TP24.1(TP) TP25.1(TP) TP26.1(TP) TP27.1(TP) U1.4(GND) U2.2(GND) U2.3(E\N\) U3.1(GND#1) U3.5(GND#5) U3.10(AGND) U3.11(GND#11) U3.13(TEST) U3.15(GND#15) U3.25(GND#25) U3.35(GND#35) U3.47(GND#47) U3.51(GND#51) U4.5(GND) U4.7(NC) U5.A5(RDN7A/DIFFIO_RX_T1N/DIFFOUT_T2N) U5.AA1(GND#AA1) U5.AA2(GND#AA2) U5.AA10(GND#AA10) U5.AA14(GND#AA14) U5.AA16(GND#AA16) U5.AA18(GND#AA18) U5.AA20(GND#AA20) U5.AA22(GND#AA22) U5.AA25(GND#AA25) U5.AA33(GND#AA33) U5.AA34(GND#AA34) U5.AB3(GND#AB3) U5.AB4(GND#AB4) U5.AB5(GND#AB5) U5.AB7(GND#AB7) U5.AB13(GND#AB13) U5.AB15(GND#AB15) U5.AB17(GND#AB17) U5.AB19(GND#AB19) U5.AB21(GND#AB21) U5.AB25(VREFB2CN0) U5.AB28(GND#AB28) U5.AB30(GND#AB30) U5.AB31(GND#AB31) U5.AB32(GND#AB32) U5.AC1(GND#AC1) U5.AC2(GND#AC2) U5.AC9(VREFB5CN0) U5.AC33(GND#AC33) U5.AC34(GND#AC34) U5.AD3(GND#AD3) U5.AD4(GND#AD4) U5.AD5(GND#AD5) U5.AD7(GND#AD7) U5.AD10(GND#AD10) U5.AD13(GND#AD13) U5.AD16(GND#AD16) U5.AD19(GND#AD19) U5.AD22(GND#AD22) U5.AD25(GND#AD25) U5.AD28(GND#AD28) U5.AD30(GND#AD30) U5.AD31(GND#AD31) U5.AD32(GND#AD32) U5.AE1(GND#AE1) U5.AE2(GND#AE2) U5.AE5(GND#AE5) U5.AE30(GND#AE30) U5.AE33(GND#AE33) U5.AE34(GND#AE34) U5.AF3(GND#AF3) U5.AF4(GND#AF4) U5.AF5(GND#AF5) U5.AF8(VREFB5AN0) U5.AF30(GND#AF30) U5.AF31(GND#AF31) U5.AF32(GND#AF32) U5.AG1(GND#AG1) U5.AG2(GND#AG2) U5.AG5(GND#AG5) U5.AG7(GND#AG7) U5.AG10(GND#AG10) U5.AG13(GND#AG13) U5.AG16(GND#AG16) U5.AG19(GND#AG19) U5.AG22(GND#AG22) U5.AG25(GND#AG25) U5.AG28(GND#AG28) U5.AG30(GND#AG30) U5.AG33(GND#AG33) U5.AG34(GND#AG34) U5.AH3(GND#AH3) U5.AH4(GND#AH4) U5.AH5(GND#AH5) U5.AH30(GND#AH30) U5.AH31(GND#AH31) U5.AH32(GND#AH32) U5.AJ1(GND#AJ1) U5.AJ2(GND#AJ2) U5.AJ5(GND#AJ5) U5.AJ30(GND#AJ30) U5.AJ33(GND#AJ33) U5.AJ34(GND#AJ34) U5.AK1(RREF_R0) U5.AK2(GND#AK2) U5.AK4(GND#AK4) U5.AK5(GND#AK5) U5.AK7(GND#AK7) U5.AK10(GND#AK10) U5.AK13(GND#AK13) U5.AK16(GND#AK16) U5.AK19(GND#AK19) U5.AK22(GND#AK22) U5.AK25(GND#AK25) U5.AK28(GND#AK28) U5.AK30(GND#AK30) U5.AK31(GND#AK31) U5.AK33(GND#AK33) U5.AL1(GND#AL1) U5.AL2(GND#AL2) U5.AL33(GND#AL33) U5.AL34(GND#AL34) U5.AN1(GND#AN1) U5.AN4(GND#AN4) U5.AN7(GND#AN7) U5.AN10(GND#AN10) U5.AN13(GND#AN13) U5.AN16(GND#AN16) U5.AN19(GND#AN19) U5.AN22(GND#AN22) U5.AN25(GND#AN25) U5.AN28(GND#AN28) U5.AN31(GND#AN31) U5.B4(GND#B4) U5.B5(RUP7A/DIFFIO_RX_T1P/DIFFOUT_T2P) U5.B7(GND#B7) U5.B10(GND#B10) U5.B13(GND#B13) U5.B16(GND#B16) U5.B19(GND#B19) U5.B22(GND#B22) U5.B25(GND#B25) U5.B28(GND#B28) U5.B31(GND#B31) U5.C1(GND#C1) U5.C2(GND#C2) U5.C33(GND#C33) U5.C34(GND#C34) U5.D1(RREF_R1) U5.D2(GND#D2) U5.D3(GND#D3) U5.D4(GND#D4) U5.D5(GND#D5) U5.D30(GND#D30) U5.D31(GND#D31) U5.D32(GND#D32) U5.D33(GND#D33) U5.E1(GND#E1) U5.E2(GND#E2) U5.E5(GND#E5) U5.E7(GND#E7) U5.E10(GND#E10) U5.E13(GND#E13) U5.E16(GND#E16) U5.E19(GND#E19) U5.E22(GND#E22) U5.E25(GND#E25) U5.E28(GND#E28) U5.E30(GND#E30) U5.E33(GND#E33) U5.E34(GND#E34) U5.F3(GND#F3) U5.F4(GND#F4) U5.F5(GND#F5) U5.F16(VREFB7CN0) U5.F30(GND#F30) U5.F31(GND#F31) U5.F32(GND#F32) U5.G1(GND#G1) U5.G2(GND#G2) U5.G5(GND#G5) U5.G14(VREFB7AN0) U5.G19(VREFB8CN0) U5.G30(GND#G30) U5.G33(GND#G33) U5.G34(GND#G34) U5.H3(GND#H3) U5.H4(GND#H4) U5.H5(GND#H5) U5.H7(GND#H7) U5.H10(GND#H10) U5.H13(GND#H13) U5.H16(GND#H16) U5.H19(GND#H19) U5.H20(VREFB8AN0) U5.H22(GND#H22) U5.H25(GND#H25) U5.H28(GND#H28) U5.H30(GND#H30) U5.H31(GND#H31) U5.H32(GND#H32) U5.J1(GND#J1) U5.J2(GND#J2) U5.J33(GND#J33) U5.J34(GND#J34) U5.K3(GND#K3) U5.K4(GND#K4) U5.K9(VREFB6AN0) U5.K31(GND#K31) U5.K32(GND#K32) U5.L1(GND#L1) U5.L2(GND#L2) U5.L7(GND#L7) U5.L10(GND#L10) U5.L13(GND#L13) U5.L16(GND#L16) U5.L19(GND#L19) U5.L22(GND#L22) U5.L25(GND#L25) U5.L28(GND#L28) U5.L33(GND#L33) U5.L34(GND#L34) U5.M3(GND#M3) U5.M4(GND#M4) U5.M21(NC_M21) U5.M22(NC_M22) U5.M25(VREFB1AN0) U5.M31(GND#M31) U5.M32(GND#M32) U5.N1(GND#N1) U5.N2(GND#N2) U5.N14(GND#N14) U5.N16(GND#N16) U5.N18(GND#N18) U5.N20(GND#N20) U5.N22(GND#N22) U5.N33(GND#N33) U5.N34(GND#N34) U5.P3(GND#P3) U5.P4(GND#P4) U5.P5(GND#P5) U5.P6(GND#P6) U5.P7(GND#P7) U5.P8(GND#P8) U5.P10(GND#P10) U5.P13(GND#P13) U5.P15(GND#P15) U5.P17(GND#P17) U5.P19(GND#P19) U5.P21(GND#P21) U5.P25(GND#P25) U5.P27(GND#P27) U5.P28(GND#P28) U5.P29(GND#P29) U5.P30(GND#P30) U5.P31(GND#P31) U5.P32(GND#P32) U5.R1(GND#R1) U5.R2(GND#R2) U5.R6(GND#R6) U5.R8(GND#R8) U5.R9(VREFB6CN0) U5.R14(GND#R14) U5.R16(GND#R16) U5.R18(GND#R18) U5.R20(GND#R20) U5.R22(GND#R22) U5.R26(VREFB1CN0) U5.R27(GND#R27) U5.R29(GND#R29) U5.R33(GND#R33) U5.R34(GND#R34) U5.T3(GND#T3) U5.T4(GND#T4) U5.T5(GND#T5) U5.T10(GND#T10) U5.T13(GND#T13) U5.T15(GND#T15) U5.T17(GND#T17) U5.T19(GND#T19) U5.T21(GND#T21) U5.T25(GND#T25) U5.T30(GND#T30) U5.T31(GND#T31) U5.T32(GND#T32) U5.U1(GND#U1) U5.U2(GND#U2) U5.U6(GND#U6) U5.U7(GND#U7) U5.U14(GND#U14) U5.U16(GND#U16) U5.U18(GND#U18) U5.U20(GND#U20) U5.U22(GND#U22) U5.U28(GND#U28) U5.U29(GND#U29) U5.U33(GND#U33) U5.U34(GND#U34) U5.V3(GND#V3) U5.V4(GND#V4) U5.V5(GND#V5) U5.V6(GND#V6) U5.V8(GND#V8) U5.V13(GND#V13) U5.V15(GND#V15) U5.V19(GND#V19) U5.V21(GND#V21) U5.V27(GND#V27) U5.V29(GND#V29) U5.V30(GND#V30) U5.V31(GND#V31) U5.V32(GND#V32) U5.W1(GND#W1) U5.W2(GND#W2) U5.W10(GND#W10) U5.W14(GND#W14) U5.W16(GND#W16) U5.W18(GND#W18) U5.W20(GND#W20) U5.W22(GND#W22) U5.W25(GND#W25) U5.W33(GND#W33) U5.W34(GND#W34) U5.Y3(GND#Y3) U5.Y4(GND#Y4) U5.Y5(GND#Y5) U5.Y6(GND#Y6) U5.Y7(GND#Y7) U5.Y13(GND#Y13) U5.Y15(GND#Y15) U5.Y17(GND#Y17) U5.Y19(GND#Y19) U5.Y21(GND#Y21) U5.Y28(GND#Y28) U5.Y29(GND#Y29) U5.Y30(GND#Y30) U5.Y31(GND#Y31) U5.Y32(GND#Y32) U6.2(GND) U7.2(NC1) U7.3(NC2) U7.4(NC3) U7.12(GND) U7.13(NC4) U7.14(NC5) U7.17(NC6) U7.21(PWRPAD) U8.2(GND#2) U8.3(GND#3) U8.15(PWRPAD) U9.5(GND) U9.8(PGND1) U9.9(PGND2) U9.15(PWRPAD) U10.2(GND#2) U10.3(GND#3) U10.15(PWRPAD) U11.4(PGND) U11.8(GND) U11.11(PWRPAD) U12.5(GND) U12.8(PGND1) U12.9(PGND2) U12.15(PWRPAD) U13.2(GND#2) U13.3(GND#3) U13.15(PWRPAD) U14.4(GND) U15.5(GND) U15.8(PGND1) U15.9(PGND2) U15.15(PWRPAD) U16.11(GND) U17.11(GND) U18.6(GND) U18.11(PWRPAD#11) U18.12(PWRPAD#12) U18.13(PWRPAD#13) U18.14(PWRPAD#14) U18.15(PWRPAD#15) U19.10(GND) U20.6(SYNC) U20.7(AGND) U20.11(GND) U20.12(PGND#12) U20.13(PGND#13) U20.14(PGND#14) U20.15(PWRPAD) Y1.2 Y1.4 Y2.2(GND)
ADBUS0: TP1.1 U3.16(ADBUS0) U5.D22(IO_8A_D22/DQ13T/DIFFOUT_T52N)
ADBUS1: TP2.1 U3.17(ADBUS1) U5.J20(IO_8A_J20/DIFFOUT_T46P)
ADBUS2: TP3.1 U3.18(ADBUS2) U5.D25(IO_8A_D25/DQS15T/DIFFIO_RX_T29P)
ADBUS3: TP4.1 U3.19(ADBUS3) U5.F21(IO_8A_F21/DQ13T/DIFFOUT_T52P)
ADC_0: U3.24(ADBUS7) U16.20(B1)
ADC_1: U3.21(ADBUS4) U16.18(B2)
ADC_2: U3.22(ADBUS5) U16.17(B3)
ADC_3: U3.23(ADBUS6) U16.16(B4)
ADC_4: U3.30(BDBUS4) U16.15(B5)
ADC_5: U3.32(BDBUS5) U16.14(B6)
ADC_6: U3.33(BDBUS6) U16.13(B7)
ADC_7: U3.34(BDBUS7) U16.12(B8)
ADC_GPIO_0: JP5.2 U16.1(A1)
ADC_GPIO_1: JP6.2 U16.3(A2)
ADC_GPIO_2: JP7.2 U16.4(A3)
ADC_GPIO_3: J3.111 U16.5(A4)
ADC_GPIO_4: J3.113 U16.6(A5)
ADC_GPIO_5: J3.115 U16.7(A6)
ADC_GPIO_6: J3.117 U16.8(A7)
ADC_GPIO_7: J3.119 U16.9(A8)
ASDI: C351.1 DN1.2 R156.2 U5.AM1(ASDO) U19.15(ASDI)
BDBUS0: TP5.1 U3.26(BDBUS0) U5.D23(IO_8A_D23/DQS13T/DIFFIO_RX_T26P)
BDBUS1: TP6.1 U3.27(BDBUS1) U5.J21(IO_8A_J21/DIFFIO_RX_T23P/DIFFOU)
BDBUS2: TP7.1 U3.28(BDBUS2) U5.D26(IO_8A_D26/DQ15T/DIFFOUT_T58N)
BDBUS3: TP8.1 U3.29(BDBUS3) U5.F22(IO_8A_F22/DQ13T/DIFFOUT_T50P)
CDBUS0: TP9.1 U3.38(CDBUS0) U5.D24(IO_8A_D24/DQ14T/DIFFIO_RX_T27N/)
CDBUS1: TP10.1 U3.39(CDBUS1) U5.H21(IO_8A_H21/DIFFIO_RX_T23N/DIFFOU)
CDBUS2: TP11.1 U3.40(CDBUS2) U5.D27(IO_8A_D27/DQ15T/DIFFOUT_T58P)
CDBUS3: TP12.1 U3.41(CDBUS3) U5.F23(IO_8A_F23/DQS14T/DIFFIO_RX_T28P)
CLK_GXB1_M: J2.54 U5.AD34(REFCLK_L0N, GXB_CMURX_L0N)
CLK_GXB1_P: J2.52 U5.AD33(REFCLK_L0P, GXB_CMURX_L0P)
CLK_GXB2_M: J2.60 U5.AB34(REFCLK_L1N, GXB_CMURX_L1N)
CLK_GXB2_P: J2.58 U5.AB33(REFCLK_L1P, GXB_CMURX_L1P)
CLK_GXB3_M: J2.53 U5.M34(REFCLK_L2N, GXB_CMURX_L2N)
CLK_GXB3_P: J2.51 U5.M33(REFCLK_L2P, GXB_CMURX_L2P)
CLK_GXB4_M: J2.59 U5.K34(REFCLK_L3N, GXB_CMURX_L3N)
CLK_GXB4_P: J2.57 U5.K33(REFCLK_L3P, GXB_CMURX_L3P)
CLK_OSCN: R76.1 U5.AP20(CLK5N_DIFFOUT_B31N) U6.4(Y)
CLK_OSCP: R76.2 U5.AN20(CLK5P_DIFFOUT_B31P) U6.3(Z)
CMOS_CLK: C46.2 R15.2 R16.1 U5.B18(CLK14P_DIFFIO_RX_T17P_DIFFOUT_T)
CMOS_PORT0_0: J1.1 U5.B15(CLK12P_DIFFIO_RX_T16P_DIFFOUT_T)
CMOS_PORT0_1: J1.3 U5.L18(IO_8C_L18/PLL_T1_CLKOUT3/DIFFOU)
CMOS_PORT0_2: J1.5 U5.K18(IO_8C_K18/PLL_T1_CLKOUT0P/DIFFO)
CMOS_PORT0_3: J1.7 U5.K19(IO_8C_K19/DIFFIO_RX_T19P/DIFFOU)
CMOS_PORT0_4: J1.9 U5.J18(IO_8C_J18/PLL_T1_CLKOUT0N/DIFFO)
CMOS_PORT0_5: J1.11 U5.J19(IO_8C_J19/DIFFIO_RX_T19N/DIFFOU)
CMOS_PORT0_6: J1.13 U5.F19(IO_8C_F19/DQ10T/DIFFOUT_T40P)
CMOS_PORT0_7: J1.15 U5.F20(IO_8C_F20/DQ10T/DIFFOUT_T40N)
CMOS_PORT0_8: J1.17 U5.E20(IO_8C_E20/DQS10T/DIFFIO_RX_T21P)
CMOS_PORT0_9: J1.19 U5.E21(IO_8C_E21/DQS11T/DIFFIO_RX_T22P)
CMOS_PORT0_10: J1.21 U5.D18(IO_8C_D18/PLL_T1_FBP/CLKOUT1/DI)
CMOS_PORT0_11: J1.23 U5.D19(IO_8C_D19/DQ10T/DIFFIO_RX_T20P/)
CMOS_PORT0_12: J1.25 U5.D20(IO_8C_D20/DQSN10T/DIFFIO_RX_T21)
CMOS_PORT0_13: J1.27 U5.D21(IO_8C_D21/DQSN11T/DIFFIO_RX_T22)
CMOS_PORT0_14: J1.29 U5.C18(IO_8C_C18/PLL_T1_FBN/CLKOUT2/DI)
CMOS_PORT0_15: J1.31 U5.C19(IO_8C_C19/DQ10T/DIFFIO_RX_T20N/)
CMOS_PORT0_16: J1.33 U5.C20(IO_8C_C20/DQ11T/DIFFOUT_T42P)
CMOS_PORT0_17: J1.35 U5.C21(IO_8C_C21/DQ11T/DIFFOUT_T42N)
CMOS_PORT0_18: J1.37 U5.B21(IO_8C_B21/DQ11T/DIFFOUT_T44N)
CMOS_PORT0_19: J1.39 U5.A21(IO_8C_A21/DQ11T/DIFFOUT_T44P)
CMOS_PORT0_20: J1.41 U5.A30(RDN8A/DIFFIO_RX_T32N/DIFFOUT_T6)
CMOS_PORT0_21: J1.43 U5.B29(IO_8A_B29/DQ17T/DIFFOUT_T62N)
CMOS_PORT1_0: J1.45 U5.B20(CLK15P_DIFFOUT_T34P)
CMOS_PORT1_1: J1.47 U5.K17(IO_7C_K17/DIFFIO_RX_T15P/DIFFOU)
CMOS_PORT1_2: J1.49 U5.K16(IO_7C_K16/DQS9T/DIFFIO_RX_T14P/)
CMOS_PORT1_3: J1.51 U5.J17(IO_7C_J17/DIFFIO_RX_T15N/DIFFOU)
CMOS_PORT1_4: J1.53 U5.J16(IO_7C_J16/DQSN9T/DIFFIO_RX_T14N)
CMOS_PORT1_5: J1.55 U5.B14(IO_7C_B14/DQ7T/DIFFOUT_T21P)
CMOS_PORT1_6: J1.57 U5.G16(IO_7C_G16/DQ9T/DIFFOUT_T29P)
CMOS_PORT1_7: J1.59 U5.F15(IO_7C_F15/DQ9T/DIFFOUT_T29N)
CMOS_PORT1_8: J1.61 U5.E14(IO_7C_E14/DQS7T/DIFFIO_RX_T11P/)
CMOS_PORT1_9: J1.63 U5.E15(IO_7C_E15/DQS8T/DIFFIO_RX_T12P/)
CMOS_PORT1_10: J1.65 U5.E17(IO_7C_E17/DQ9T/DIFFOUT_T27N)
CMOS_PORT1_11: J1.67 U5.D14(IO_7C_D14/DQSN7T/DIFFIO_RX_T11N)
CMOS_PORT1_12: J1.69 U5.D15(IO_7C_D15/DQSN8T/DIFFIO_RX_T12N)
CMOS_PORT1_13: J1.71 U5.D16(IO_7C_D16/DQ8T/DIFFIO_RX_T13P/D)
CMOS_PORT1_14: J1.73 U5.D17(IO_7C_D17/DQ8T/DIFFOUT_T25N)
CMOS_PORT1_15: J1.75 U5.C14(IO_7C_C14/DQ7T/DIFFOUT_T23P)
CMOS_PORT1_16: J1.77 U5.C15(IO_7C_C15/DQ7T/DIFFOUT_T23N)
CMOS_PORT1_17: J1.79 U5.C16(IO_7C_C16/DQ8T/DIFFIO_RX_T13N/D)
CMOS_PORT1_18: J1.81 U5.C17(IO_7C_C17/DQ8T/DIFFOUT_T25P)
CMOS_PORT1_19: J1.83 U5.A14(IO_7C_A14/DQ7T/DIFFOUT_T21N)
CMOS_PORT1_20: J1.85 U5.A31(IO_8A_A31/DQ17T/DIFFOUT_T64N)
CMOS_PORT1_21: J1.87 U5.B30(RUP8A/DIFFIO_RX_T32P/DIFFOUT_T6)
CMOS_SP1: J4.26 U5.A10(IO_7A_A10/DQ2T/DIFFOUT_T5N)
CMOS_SP2: J4.28 U5.A11(IO_7A_A11/DQSN6T/DIFFIO_RX_T8N/)
CMOS_SP3: J4.38 U5.A12(IO_7A_A12/DQ6T/DIFFIO_RX_T9N/DI)
CMOS_SP4: J4.40 U5.A13(IO_7A_A13/DQ6T/DIFFOUT_T17N)
CMOS_SP5: J4.46 U5.A4(IO_7A_A4/DQ1T/DIFFOUT_T1P)
CMOS_SP6: J4.50 U5.A6(IO_7A_A6/DQ1T/DIFFOUT_T1N)
CMOS_SP7: J4.52 U5.A7(IO_7A_A7/DQ1T/DIFFOUT_T3N)
CPU_RESET: R103.1 U5.A17(CLK13N_DIFFOUT_T31N)
DA0N: J4.165 U5.AB26(IO_2C_AB26/DQ10L/DIFFIO_TX_L19N)
DA0P: J4.163 U5.AC25(IO_2C_AC25/DQ10L/DIFFIO_TX_L19P)
DA1N: J4.159 U5.AA27(IO_2C_AA27/DQ8L/DIFFIO_TX_L16N/)
DA1P: J4.157 U5.AA26(IO_2C_AA26/DQ8L/DIFFIO_TX_L16P/)
DA2N: J4.153 U5.Y25(IO_2C_Y25/DIFFIO_TX_L20N/DIFFOU)
DA2P: J4.151 U5.AA24(IO_2C_AA24/DIFFIO_TX_L20P/DIFFO)
DA3N: J4.147 U5.Y24(IO_2C_Y24/DQ9L/DIFFIO_TX_L18N/D)
DA3P: J4.145 U5.Y23(IO_2C_Y23/DQ9L/DIFFIO_TX_L18P/D)
DA4N: J4.141 U5.W23(IO_2C_W23/DQ9L/DIFFIO_TX_L17N/D)
DA4P: J4.139 U5.Y22(IO_2C_Y22/DQ9L/DIFFIO_TX_L17P/D)
DA5N: J4.135 U5.V25(IO_2C_V25/DIFFIO_TX_L15N/DIFFOU)
DA5P: J4.133 U5.W24(IO_2C_W24/DIFFIO_TX_L15P/DIFFOU)
DA6N: J4.129 U5.U25(IO_1C_U25/DQ6L/DIFFIO_TX_L12N/D)
DA6P: J4.127 U5.T24(IO_1C_T24/DQ6L/DIFFIO_TX_L12P/D)
DA7N: J4.123 U5.R24(IO_1C_R24/DQ7L/DIFFIO_TX_L13N/D)
DA7P: J4.121 U5.R23(IO_1C_R23/DQ7L/DIFFIO_TX_L13P/D)
DA8N: J4.111 U5.J27(IO_1A_J27/DQ4L/DIFFIO_TX_L7N/DI)
DA8P: J4.109 U5.H26(IO_1A_H26/DQ4L/DIFFIO_TX_L7P/DI)
DA9N: J4.105 U5.P24(IO_1A_P24/DQ3L/DIFFIO_TX_L5N/DI)
DA9P: J4.103 U5.P23(IO_1A_P23/DQ3L/DIFFIO_TX_L5P/DI)
DA10N: J4.99 U5.N26(IO_1C_N26/DIFFIO_TX_L9N/DIFFOUT)
DA10P: J4.97 U5.N25(IO_1C_N25/DIFFIO_TX_L9P/DIFFOUT)
DA11N: J4.93 U5.M24(IO_1A_M24/DIFFIO_TX_L8N/DIFFOUT)
DA11P: J4.91 U5.N23(IO_1A_N23/DIFFIO_TX_L8P/DIFFOUT)
DA12N: J4.87 U5.N27(IO_1C_N27/DQ5L/DIFFIO_TX_L10N/D)
DA12P: J4.85 U5.M26(IO_1C_M26/DQ5L/DIFFIO_TX_L10P/D)
DA13N: J4.81 U5.K27(IO_1A_K27/DQ2L/DIFFIO_TX_L4N/DI)
DA13P: J4.79 U5.K26(IO_1A_K26/DQ2L/DIFFIO_TX_L4P/DI)
DA14N: J4.75 U5.L23(IO_1A_L23/DQ1L/DIFFIO_TX_L2N/DI)
DA14P: J4.73 U5.M23(IO_1A_M23/DQ1L/DIFFIO_TX_L2P/DI)
DA15N: J4.69 U5.K24(IO_1A_K24/DIFFIO_TX_L1N/DIFFOUT)
DA15P: J4.67 U5.L24(IO_1A_L24/DIFFIO_TX_L1P/DIFFOUT)
DAC_0: U3.46(CDBUS7) U17.20(B1)
DAC_1: U3.43(CDBUS4) U17.18(B2)
DAC_2: U3.44(CDBUS5) U17.17(B3)
DAC_3: U3.45(CDBUS6) U17.16(B4)
DAC_4: U3.55(DDBUS4) U17.15(B5)
DAC_5: U3.57(DDBUS5) U17.14(B6)
DAC_6: U5.B11(IO_7A_B11/DQS6T/DIFFIO_RX_T8P/D) U17.13(B7)
DAC_7: U5.B12(IO_7A_B12/DQ6T/DIFFIO_RX_T9P/DI) U17.12(B8)
DAC_GPIO_0: J4.45 U17.1(A1)
DAC_GPIO_1: J4.47 U17.3(A2)
DAC_GPIO_2: J4.49 U17.4(A3)
DAC_GPIO_3: J4.51 U17.5(A4)
DAC_GPIO_4: J4.53 U17.6(A5)
DAC_GPIO_5: J4.55 U17.7(A6)
DAC_GPIO_6: J4.57 U17.8(A7)
DAC_GPIO_7: J4.59 U17.9(A8)
DACLKN: J4.117 U5.M29(IO_1C_M29/PLL_L2_CLKOUT0N/DIFFI)
DACLKP: J4.115 U5.M28(IO_1C_M28/PLL_L2_FB_CLKOUT0P/DI)
DATA0: C354.1 R127.2 R130.1 R134.1 R135.2 U5.P26(IO_1C_P26/DQ6L/DIFFIO_TX_L11N/D)
DATA1: R136.2 U5.R25(IO_1C_R25/DQ6L/DIFFIO_TX_L11P/D)
DB0N: J4.166 U5.AG12(IO_5A_AG12/DQ3R/DIFFIO_TX_R6N/D)
DB0P: J4.164 U5.AF12(IO_5A_AF12/DQ3R/DIFFIO_TX_R6P/D)
DB1N: J4.160 U5.AF11(IO_5A_AF11/DQ1R/DIFFIO_TX_R3N/D)
DB1P: J4.158 U5.AE12(IO_5A_AE12/DQ1R/DIFFIO_TX_R3P/D)
DB2N: J4.154 U5.AD11(IO_5A_AD11/DIFFIO_TX_R8N/DIFFOU)
DB2P: J4.152 U5.AD12(IO_5A_AD12/DIFFIO_TX_R8P/DIFFOU)
DB3N: J4.148 U5.AE9(IO_5A_AE9/DQ3R/DIFFIO_TX_R5N/DI)
DB3P: J4.146 U5.AE10(IO_5A_AE10/DQ3R/DIFFIO_TX_R5P/D)
DB4N: J4.142 U5.AE8(IO_5A_AE8/DQ2R/DIFFIO_TX_R4N/DI)
DB4P: J4.140 U5.AF9(IO_5A_AF9/DQ2R/DIFFIO_TX_R4P/DI)
DB5N: J4.136 U5.AF10(IO_5A_AF10/DQ4R/DIFFIO_TX_R7N/D)
DB5P: J4.134 U5.AG11(IO_5A_AG11/DQ4R/DIFFIO_TX_R7P/D)
DB6N: J4.130 U5.AC11(IO_5A_AC11/DIFFIO_TX_R1N/DIFFOU)
DB6P: J4.128 U5.AC12(IO_5A_AC12/DIFFIO_TX_R1P/DIFFOU)
DB7N: J4.124 U5.AB9(IO_5C_AB9/DQ5R/DIFFIO_TX_R10N/D)
DB7P: J4.122 U5.AC10(IO_5C_AC10/DQ5R/DIFFIO_TX_R10P/)
DB8N: J4.112 U5.AB10(IO_5C_AB10/DIFFIO_TX_R9N/DIFFOU)
DB8P: J4.110 U5.AB11(IO_5C_AB11/DIFFIO_TX_R9P/DIFFOU)
DB9N: J4.106 U5.AB12(IO_5A_AB12/DQ1R/DIFFIO_TX_R2N/D)
DB9P: J4.104 U5.AA12(IO_5A_AA12/DQ1R/DIFFIO_TX_R2P/D)
DB10N: J4.100 U5.Y12(IO_5C_Y12/DQ6R/DIFFIO_TX_R12N/D)
DB10P: J4.98 U5.W12(IO_5C_W12/DQ6R/DIFFIO_TX_R12P/D)
DB11N: J4.94 U5.AA8(IO_5C_AA8/DQ7R/DIFFIO_TX_R13N/D)
DB11P: J4.92 U5.AA9(IO_5C_AA9/DQ7R/DIFFIO_TX_R13P/D)
DB12N: J4.88 U5.Y10(IO_5C_Y10/DQ6R/DIFFIO_TX_R11N/D)
DB12P: J4.86 U5.AA11(IO_5C_AA11/DQ6R/DIFFIO_TX_R11P/)
DB13N: J4.82 U5.V10(IO_5C_V10/DIFFIO_TX_R14N/DIFFOU)
DB13P: J4.80 U5.W11(IO_5C_W11/DIFFIO_TX_R14P/DIFFOU)
DB14N: J4.76 U5.R10(IO_6C_R10/DQ8R/DIFFIO_TX_R16N/D)
DB14P: J4.74 U5.R11(IO_6C_R11/DQ8R/DIFFIO_TX_R16P/D)
DB15N: J4.70 U5.U10(IO_6C_U10/DQ9R/DIFFIO_TX_R17N/D)
DB15P: J4.68 U5.T11(IO_6C_T11/DQ9R/DIFFIO_TX_R17P/D)
DBCLKN: J4.39 U5.U9(IO_6C_U9/PLL_R2_CLKOUT0N/DIFFIO)
DBCLKP: J4.37 U5.T9(IO_6C_T9/PLL_R2_FB_CLKOUT0P/DIF)
DCLK: C353.1 DN2.1 R126.2 U5.AM3(DCLK) U19.16(DCLK)
DCLK_M: J3.56 R54.1 U5.AA6(CLK8N)
DCLK_P: J3.58 R54.2 U5.AA7(CLK8P)
DDR2_A0: J6.102(A0) RN12.6 U5.AE24(IO_2A_AE24/DQ14L/DIFFIO_TX_L26N)
DDR2_A1: J6.101(A1) RN13.7 U5.AF23(IO_2A_AF23/DQ14L/DIFFIO_TX_L26P)
DDR2_A2: J6.100(A2) RN13.8 U5.AF25(IO_2A_AF25/DQ11L/DIFFIO_TX_L22N)
DDR2_A3: J6.99(A3) RN13.5 U5.AF26(IO_2A_AF26/DQ12L/DIFFIO_TX_L24P)
DDR2_A4: J6.98(A4) RN13.6 U5.AF27(IO_2A_AF27/DQ12L/DIFFIO_TX_L24N)
DDR2_A5: J6.97(A5) RN18.7 U5.AG23(IO_2A_AG23/DQ12L/DIFFIO_TX_L23P)
DDR2_A6: J6.94(A6) RN18.8 U5.AG24(IO_2A_AG24/DQ11L/DIFFIO_TX_L22P)
DDR2_A7: J6.92(A7) RN18.6 U5.AG26(IO_2A_AG26/DQ13L/DIFFIO_TX_L25P)
DDR2_A8: J6.93(A8) RN18.5 U5.AG27(IO_2A_AG27/DQ13L/DIFFIO_TX_L25N)
DDR2_A9: J6.91(A9) RN19.7 U5.AH28(IO_2A_AH28/DQS12L/DIFFIO_RX_L24)
DDR2_A10: J6.105(A10/AP) RN12.5 U5.AJ26(IO_2A_AJ26/DQ11L/DIFFIO_RX_L22P)
DDR2_A11: J6.90(A11) RN19.8 U5.AJ28(IO_2A_AJ28/DQ13L/DIFFIO_RX_L25P)
DDR2_A12: J6.89(A12) RN19.5 U5.AJ29(IO_2A_AJ29/DQ13L/DIFFIO_RX_L25N)
DDR2_A13: J6.116(A13) RN8.8 U5.AK27(IO_2A_AK27/DQ11L/DIFFIO_RX_L22N)
DDR2_A14: J6.86(A14) RN19.6 U5.AL29(IO_2A_AL29/DQSN14L/DIFFIO_RX_L2)
DDR2_A15: J6.84(A15) RN24.7 U5.AM28(IO_2A_AM28/DQS14L/DIFFIO_RX_L27)
DDR2_BA0: J6.107(BA0) RN12.7 U5.AE15(IO_4A_AE15/DIFFIO_RX_B23P/DIFFO)
DDR2_BA1: J6.106(BA1) RN12.8 U5.AF15(IO_4A_AF15/DIFFIO_RX_B23N/DIFFO)
DDR2_BA2: J6.85(BA2) RN24.8 U5.AF14(IO_4A_AF14/DIFFOUT_B46P)
DDR2_CAS_N: J6.113(C\A\S\) RN9.7 U5.AD17(IO_4C_AD17/DQ9B/DIFFOUT_B38P)
DDR2_CKE0: J6.79(CKE0) RN24.6 U5.AJ12(IO_4A_AJ12/DQ13B/DIFFOUT_B50P)
DDR2_CKE1: J6.80(CKE1) RN24.5 U5.AJ20(IO_3C_AJ20/DQ8B/DIFFOUT_B25N)
DDR2_CLK_N0: J6.32(C\K\0) U5.AF16(IO_4C_AF16/DQSN9B/DIFFIO_RX_B19)
DDR2_CLK_N1: J6.166(C\K\1) U5.AJ15(IO_4C_AJ15/DQ9B/DIFFOUT_B36N)
DDR2_CLK_P0: J6.30(CK0) U5.AE16(IO_4C_AE16/DQS9B/DIFFIO_RX_B19P)
DDR2_CLK_P1: J6.164(CK1) U5.AH16(IO_4C_AH16/DQ9B/DIFFOUT_B36P)
DDR2_CS_N0: J6.110(S\0) RN9.8 U5.AK17(IO_4C_AK17/DQ9B/DIFFOUT_B38N)
DDR2_CS_N1: J6.115(S\1) RN8.7 U5.AL18(IO_3C_AL18/PLL_B1_FBP/CLKOUT1/D)
DDR2_DM0: J6.10(DM0) U5.AP10(IO_4A_AP10/DQ16B/DIFFOUT_B60N)
DDR2_DM1: J6.26(DM1) U5.AK12(IO_4A_AK12/DQ13B/DIFFOUT_B52P)
DDR2_DM2: J6.52(DM2) U5.AJ19(IO_3C_AJ19/DQ8B/DIFFOUT_B25P)
DDR2_DM3: J6.67(DM3) U5.AH13(IO_4A_AH13/DQ14B/DIFFIO_RX_B27P)
DDR2_DM4: J6.130(DM4) U5.AM26(IO_3A_AM26/DQ2B/DIFFOUT_B5N)
DDR2_DM5: J6.147(DM5) U5.AH22(IO_3A_AH22/DQ5B/DIFFOUT_B15N)
DDR2_DM6: J6.170(DM6) U5.AM17(IO_4C_AM17/DQ10B/DIFFOUT_B40P)
DDR2_DM7: J6.185(DM7) U5.AM25(IO_3A_AM25/DQSN3B/DIFFIO_RX_B4N)
DDR2_DQ0: J6.5(DQ0) U5.AP4(IO_4A_AP4/DQ17B/DIFFOUT_B64P)
DDR2_DQ1: J6.7(DQ1) U5.AP5(RDN4A/DIFFIO_RX_B32N/DIFFOUT_B6)
DDR2_DQ2: J6.17(DQ2) U5.AP6(IO_4A_AP6/DQ17B/DIFFOUT_B64N)
DDR2_DQ3: J6.19(DQ3) U5.AP7(IO_4A_AP7/DQ17B/DIFFOUT_B62N)
DDR2_DQ4: J6.4(DQ4) U5.AN6(IO_4A_AN6/DQ17B/DIFFOUT_B62P)
DDR2_DQ5: J6.6(DQ5) U5.AN5(RUP4A/DIFFIO_RX_B32P/DIFFOUT_B6)
DDR2_DQ6: J6.14(DQ6) U5.AN9(IO_4A_AN9/DQ16B/DIFFIO_RX_B30P/)
DDR2_DQ7: J6.16(DQ7) U5.AP9(IO_4A_AP9/DQ16B/DIFFIO_RX_B30N/)
DDR2_DQ8: J6.23(DQ8) U5.AM13(IO_4A_AM13/DQ12B/DIFFOUT_B48P)
DDR2_DQ9: J6.25(DQ9) U5.AL12(IO_4A_AL12/DQ13B/DIFFOUT_B52N)
DDR2_DQ10: J6.35(DQ10) U5.AL13(IO_4A_AL13/DQ13B/DIFFOUT_B50N)
DDR2_DQ11: J6.37(DQ11) U5.AP13(IO_4A_AP13/DQ12B/DIFFOUT_B48N)
DDR2_DQ12: J6.20(DQ12) U5.AM11(IO_4A_AM11/DQSN13B/DIFFIO_RX_B2)
DDR2_DQ13: J6.22(DQ13) U5.AN12(IO_4A_AN12/DQ12B/DIFFIO_RX_B24P)
DDR2_DQ14: J6.36(DQ14) U5.AL11(IO_4A_AL11/DQS13B/DIFFIO_RX_B26)
DDR2_DQ15: J6.38(DQ15) U5.AP12(IO_4A_AP12/DQ12B/DIFFIO_RX_B24N)
DDR2_DQ16: J6.43(DQ16) U5.AL21(IO_3C_AL21/DQSN7B/DIFFIO_RX_B11)
DDR2_DQ17: J6.45(DQ17) U5.AM21(IO_3C_AM21/DQ7B/DIFFOUT_B23N)
DDR2_DQ18: J6.55(DQ18) U5.AL19(IO_3C_AL19/DQ8B/DIFFIO_RX_B13P/)
DDR2_DQ19: J6.57(DQ19) U5.AM19(IO_3C_AM19/DQ8B/DIFFIO_RX_B13N/)
DDR2_DQ20: J6.44(DQ20) U5.AN21(IO_3C_AN21/DQ7B/DIFFOUT_B21N)
DDR2_DQ21: J6.46(DQ21) U5.AK21(IO_3C_AK21/DQS7B/DIFFIO_RX_B11P)
DDR2_DQ22: J6.56(DQ22) U5.AM20(IO_3C_AM20/DQ7B/DIFFOUT_B23P)
DDR2_DQ23: J6.58(DQ23) U5.AP21(IO_3C_AP21/DQ7B/DIFFOUT_B21P)
DDR2_DQ24: J6.61(DQ24) U5.AM10(IO_4A_AM10/DQSN15B/DIFFIO_RX_B2)
DDR2_DQ25: J6.63(DQ25) U5.AL10(IO_4A_AL10/DQS15B/DIFFIO_RX_B29)
DDR2_DQ26: J6.73(DQ26) U5.AL9(IO_4A_AL9/DQ15B/DIFFOUT_B58P)
DDR2_DQ27: J6.75(DQ27) U5.AL8(IO_4A_AL8/DQ15B/DIFFOUT_B58N)
