# Allegro board AUTOSAVE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
INPUT22_M: length 118.4
  TOP w0.114: U5.AD6 v2(100.95,88.2)
  L4-SIG2 w0.102: v1(98.2,147.55) 97.79,147.14 97.28,147.14 97.05,147.37 97.05,147.68 97.36,147.98 97.57,147.98 97.84,148.25 97.84,148.65 97.17,149.33 91.06,149.33 89.84,148.11 89.84,145.07 89.43,144.66 89.43,143.27 89.84,142.86 89.84,140.03 90.42,139.45 90.42,138.49 91.77,137.15 91.77,136.35 92.46,135.66 92.8,135.66 97.49,130.98 97.49,128.87 96.27,127.65 96.27,127.65 96.16,127.55 96.16,127.34 96.27,127.24 97.22,127.24 97.49,126.98 97.49,126.54 97.22,126.28 96.27,126.28 96.16,126.18 96.16,125.97 96.27,125.87 97.22,125.87 97.49,125.61 97.49,125.17 97.22,124.91 96.27,124.91 96.16,124.8 96.16,124.6 96.27,124.5 97.22,124.5 97.49,124.23 97.49,123.8 97.22,123.53 96.27,123.53 96.16,123.43 96.16,123.23 96.27,123.13 97.22,123.13 97.49,122.86 97.49,122.43 97.22,122.16 96.27,122.16 96.16,122.06 96.16,121.86 96.27,121.76 97.22,121.76 97.49,121.49 97.49,121.06 97.22,120.79 96.27,120.79 96.16,120.69 96.16,120.49 96.27,120.39 97.22,120.39 97.49,120.12 97.49,119.69 97.22,119.42 96.27,119.42 96.16,119.32 96.16,119.12 96.27,119.01 97.22,119.01 97.49,118.75 97.49,118.31 97.22,118.05 96.27,118.05 96.16,117.95 96.16,117.74 96.27,117.64 97.22,117.64 97.49,117.38 97.49,116.94 97.22,116.68 96.27,116.68 96.16,116.58 96.16,116.37 96.27,116.27 97.22,116.27 97.49,116.01 97.49,115.57 97.22,115.31 96.27,115.31 96.16,115.2 96.16,115 96.27,114.9 97.22,114.9 97.49,114.63 97.49,114.2 97.22,113.93 96.27,113.93 96.16,113.83 96.16,113.63 96.27,113.53 97.22,113.53 97.49,113.26 97.49,112.83 97.22,112.56 96.27,112.56 96.16,112.46 96.16,112.26 96.27,112.16 97.22,112.16 97.49,111.89 97.49,111.46 97.22,111.19 96.27,111.19 96.16,111.09 96.16,110.89 96.27,110.78 97.22,110.78 97.49,110.52 97.49,110.08 97.22,109.82 96.27,109.82 96.16,109.72 96.16,109.51 96.27,109.41 97.22,109.41 97.49,109.15 97.49,108.71 97.22,108.45 96.27,108.45 96.16,108.35 96.16,108.14 96.27,108.04 97.22,108.04 97.49,107.78 97.49,107.34 97.22,107.08 96.27,107.08 96.16,106.97 96.16,106.77 96.27,106.67 97.22,106.67 97.49,106.4 97.49,105.97 97.22,105.7 96.27,105.7 96.16,105.6 96.16,105.4 96.27,105.3 97.22,105.3 97.49,105.03 97.49,101.6 100.76,98.32 100.76,96.24 100.57,96.05 100.57,87.87 100.66,87.78 100.89,87.78 100.97,87.86 100.97,88.18 v2(100.95,88.2)
  BOTTOM w0.114: v1(98.2,147.55) 98.15,147.6 98.15,148.04 98.35,148.24 98.35,149.84 J3.88
INPUT22_P: length 118.4
  TOP w0.114: U5.AE7 v2(99.95,87.2)
  L4-SIG2 w0.102: v2(99.95,87.2) 100.33,87.58 100.33,94.07 100.29,94.11 100.29,96.16 100.48,96.36 100.48,98.21 97.21,101.48 97.21,102.14 97.1,102.24 97,102.24 96.9,102.34 96.9,102.55 97,102.65 97.1,102.65 97.21,102.75 97.21,102.95 97.1,103.06 97,103.06 96.9,103.16 96.9,103.36 97,103.46 97.1,103.46 97.21,103.56 97.21,104.92 97.1,105.02 96.15,105.02 95.89,105.28 95.89,105.72 96.15,105.98 97.1,105.98 97.21,106.09 97.21,106.29 97.1,106.39 96.15,106.39 95.89,106.66 95.89,107.09 96.15,107.36 97.1,107.36 97.21,107.46 97.21,107.66 97.1,107.76 96.15,107.76 95.89,108.03 95.89,108.46 96.15,108.73 97.1,108.73 97.21,108.83 97.21,109.03 97.1,109.13 96.15,109.13 95.89,109.4 95.89,109.83 96.15,110.1 97.1,110.1 97.21,110.2 97.21,110.4 97.1,110.5 96.15,110.5 95.89,110.77 95.89,111.2 96.15,111.47 97.1,111.47 97.21,111.57 97.21,111.77 97.1,111.88 96.15,111.88 95.89,112.14 95.89,112.58 96.15,112.84 97.1,112.84 97.21,112.94 97.21,113.15 97.1,113.25 96.15,113.25 95.89,113.51 95.89,113.95 96.15,114.21 97.1,114.21 97.21,114.31 97.21,114.52 97.1,114.62 96.15,114.62 95.89,114.88 95.89,115.32 96.15,115.58 97.1,115.58 97.21,115.69 97.21,115.89 97.1,115.99 96.15,115.99 95.89,116.26 95.89,116.69 96.15,116.96 97.1,116.96 97.21,117.06 97.21,117.26 97.1,117.36 96.15,117.36 95.89,117.63 95.89,118.06 96.15,118.33 97.1,118.33 97.21,118.43 97.21,118.63 97.1,118.73 96.15,118.73 95.89,119 95.89,119.43 96.15,119.7 97.1,119.7 97.21,119.8 97.21,120 97.1,120.11 96.15,120.11 95.89,120.37 95.89,120.81 96.15,121.07 97.1,121.07 97.21,121.17 97.21,121.38 97.1,121.48 96.15,121.48 95.89,121.74 95.89,122.18 96.15,122.44 97.1,122.44 97.21,122.54 97.21,122.75 97.1,122.85 96.15,122.85 95.89,123.11 95.89,123.55 96.15,123.81 97.1,123.81 97.21,123.92 97.21,124.12 97.1,124.22 96.15,124.22 95.89,124.49 95.89,124.92 96.15,125.19 97.1,125.19 97.21,125.29 97.21,125.49 97.1,125.59 96.15,125.59 95.89,125.86 95.89,126.29 96.15,126.56 97.1,126.56 97.21,126.66 97.21,126.86 97.1,126.96 96.15,126.96 95.89,127.23 95.89,127.66 96.15,127.93 96.15,127.93 97.21,128.98 97.21,130.86 92.68,135.38 92.34,135.38 91.49,136.23 91.49,137.03 90.14,138.38 90.14,139.33 89.56,139.91 89.56,142.75 89.15,143.15 89.15,144.78 89.56,145.19 89.56,148.22 90.94,149.61 97.28,149.61 98.12,148.77 98.12,148.13 v1(97.54,147.55)
  BOTTOM w0.114: J3.90 98.02,149.86 98.02,148.3 97.87,148.15 97.87,147.88 v1(97.54,147.55)
INPUT23_M: length 118.6
  TOP w0.114: U5.AD8 v2(100.95,86.2)
  L3-SIG1 w0.102: v2(100.95,86.2) 100.95,85.76 100.56,85.37 100.56,85.06 100.33,84.84 100.33,84 100.15,83.82 100.11,83.82 99.11,83.82 98.11,83.82 97.11,83.82 96.11,83.82 95.79,83.82 95.57,84.04 95.57,93.36 95.57,93.55 95.56,93.56 95.56,93.77 95.02,94.32 95.02,94.44 94.13,95.33 94.13,103.34 92.21,105.26 92.21,106.59 92.56,106.94 93.51,106.94 93.78,107.2 93.78,107.64 93.51,107.9 92.31,107.9 92.21,108 92.21,108.21 92.31,108.31 93.51,108.31 93.78,108.57 93.78,109.01 93.51,109.27 92.31,109.27 92.21,109.38 92.21,109.58 92.31,109.68 93.51,109.68 93.78,109.95 93.78,110.38 93.51,110.65 92.31,110.65 92.21,110.75 92.21,110.95 92.31,111.05 93.51,111.05 93.78,111.32 93.78,111.75 93.51,112.02 92.31,112.02 92.21,112.12 92.21,112.32 92.31,112.42 93.51,112.42 93.78,112.69 93.78,113.12 93.51,113.39 92.31,113.39 92.21,113.49 92.21,113.69 92.31,113.8 93.51,113.8 93.78,114.06 93.78,114.5 93.51,114.76 92.31,114.76 92.21,114.86 92.21,115.07 92.31,115.17 93.51,115.17 93.78,115.43 93.78,115.87 93.51,116.13 92.31,116.13 92.21,116.23 92.21,116.44 92.31,116.54 93.51,116.54 93.78,116.8 93.78,117.24 93.51,117.5 92.31,117.5 92.21,117.61 92.21,117.81 92.31,117.91 93.51,117.91 93.78,118.18 93.78,118.61 93.51,118.88 92.31,118.88 92.21,118.98 92.21,119.18 92.31,119.28 93.51,119.28 93.78,119.55 93.78,119.98 93.51,120.25 92.31,120.25 92.21,120.35 92.21,120.55 92.31,120.65 93.51,120.65 93.78,120.92 93.78,121.35 93.51,121.62 92.31,121.62 92.21,121.72 92.21,121.92 92.31,122.03 93.51,122.03 93.78,122.29 93.78,122.73 93.51,122.99 92.31,122.99 92.21,123.09 92.21,123.3 92.31,123.4 93.51,123.4 93.78,123.66 93.78,124.1 93.51,124.36 92.31,124.36 92.21,124.46 92.21,124.67 92.31,124.77 93.51,124.77 93.78,125.03 93.78,125.47 93.51,125.73 92.31,125.73 92.21,125.84 92.21,126.04 92.31,126.14 93.51,126.14 93.78,126.41 93.78,126.84 93.51,127.11 92.31,127.11 92.21,127.21 92.21,128.25 93.9,129.94 93.9,139.5 93.09,140.31 93.09,141.69 96.88,145.48 96.88,148.11 v1(97.1,148.34)
  BOTTOM w0.114: J3.94 96.84,149.83 96.84,148.6 v1(97.1,148.34)
INPUT23_P: length 118.5
  TOP w0.114: U5.AD9 v2(100.95,85.2)
  L3-SIG1 w0.102: v1(96.37,148.34) 96.6,148.11 96.6,145.59 92.81,141.81 92.81,140.19 93.62,139.38 93.62,130.05 91.93,128.36 91.93,127.09 92.2,126.83 93.4,126.83 93.5,126.72 93.5,126.52 93.4,126.42 92.2,126.42 91.93,126.15 91.93,125.72 92.2,125.45 93.4,125.45 93.5,125.35 93.5,125.15 93.4,125.05 92.2,125.05 91.93,124.78 91.93,124.35 92.2,124.08 93.4,124.08 93.5,123.98 93.5,123.78 93.4,123.68 92.2,123.68 91.93,123.41 91.93,122.98 92.2,122.71 93.4,122.71 93.5,122.61 93.5,122.41 93.4,122.3 92.2,122.3 91.93,122.04 91.93,121.6 92.2,121.34 93.4,121.34 93.5,121.24 93.5,121.03 93.4,120.93 92.2,120.93 91.93,120.67 91.93,120.23 92.2,119.97 93.4,119.97 93.5,119.87 93.5,119.66 93.4,119.56 92.2,119.56 91.93,119.3 91.93,118.86 92.2,118.6 93.4,118.6 93.5,118.49 93.5,118.29 93.4,118.19 92.2,118.19 91.93,117.92 91.93,117.49 92.2,117.22 93.4,117.22 93.5,117.12 93.5,116.92 93.4,116.82 92.2,116.82 91.93,116.55 91.93,116.12 92.2,115.85 93.4,115.85 93.5,115.75 93.5,115.55 93.4,115.45 92.2,115.45 91.93,115.18 91.93,114.75 92.2,114.48 93.4,114.48 93.5,114.38 93.5,114.18 93.4,114.08 92.2,114.08 91.93,113.81 91.93,113.38 92.2,113.11 93.4,113.11 93.5,113.01 93.5,112.81 93.4,112.7 92.2,112.7 91.93,112.44 91.93,112 92.2,111.74 93.4,111.74 93.5,111.64 93.5,111.43 93.4,111.33 92.2,111.33 91.93,111.07 91.93,110.63 92.2,110.37 93.4,110.37 93.5,110.27 93.5,110.06 93.4,109.96 92.2,109.96 91.93,109.7 91.93,109.26 92.2,109 93.4,109 93.5,108.89 93.5,108.69 93.4,108.59 92.2,108.59 91.93,108.32 91.93,107.89 92.2,107.62 93.4,107.62 93.5,107.52 93.5,107.32 93.4,107.22 92.43,107.22 91.92,106.71 91.92,105.99 91.82,105.89 91.77,105.89 91.67,105.79 91.67,105.59 91.77,105.49 91.82,105.49 91.92,105.38 91.92,105.16 93.85,103.23 93.85,95.21 94.74,94.32 94.74,94.2 95.03,93.91 95.09,93.91 95.33,93.68 95.33,93.46 95.33,93.46 95.33,93.26 95.33,93.26 95.33,83.94 95.69,83.58 96.21,83.58 96.21,83.58 96.69,83.58 96.69,83.58 97.21,83.58 97.21,83.58 97.69,83.58 97.69,83.58 98.21,83.58 98.21,83.58 98.69,83.58 98.69,83.58 99.21,83.58 99.21,83.58 99.69,83.58 99.69,83.58 100.21,83.58 100.21,83.58 100.25,83.58 100.57,83.9 100.57,84.72 100.95,85.1 v2(100.95,85.2)
  BOTTOM w0.114: v1(96.37,148.34) 96.52,148.49 96.52,149.86 J3.96
INPUT24_M: length 118.4
  TOP w0.114: U5.AC7 v2(101.95,87.2)
  L10-SIG4 w0.102: v1(95.58,147.83) 95.35,147.6 95.35,143.83 101.07,138.11 101.07,136.04 101.17,135.94 102,135.94 102.26,135.67 102.26,135.24 102,134.97 101.17,134.97 101.07,134.87 101.07,134.67 101.17,134.57 102,134.57 102.26,134.3 102.26,133.87 102,133.6 101.17,133.6 101.07,133.5 101.07,133.3 101.17,133.2 102,133.2 102.26,132.93 102.26,132.5 102,132.23 101.17,132.23 101.07,132.13 101.07,131.93 101.17,131.82 102,131.82 102.26,131.56 102.26,131.12 102,130.86 101.17,130.86 101.07,130.76 101.07,130.55 101.17,130.45 102,130.45 102.26,130.19 102.26,129.75 102,129.49 101.17,129.49 101.07,129.39 101.07,129.18 101.17,129.08 102,129.08 102.26,128.82 102.26,128.38 102,128.12 101.17,128.12 101.07,128.01 101.07,127.81 101.17,127.71 102,127.71 102.26,127.44 102.26,127.01 102,126.74 101.17,126.74 101.07,126.64 101.07,126.44 101.17,126.34 102,126.34 102.26,126.07 102.26,125.64 102,125.37 101.17,125.37 101.07,125.27 101.07,125.07 101.17,124.97 102,124.97 102.26,124.7 102.26,124.27 102,124 101.17,124 101.07,123.9 101.07,123.7 101.17,123.59 102,123.59 102.26,123.33 102.26,122.89 102,122.63 101.17,122.63 101.07,122.53 101.07,122.32 101.17,122.22 102,122.22 102.26,121.96 102.26,121.52 102,121.26 101.17,121.26 101.07,121.16 101.07,120.95 101.17,120.85 102,120.85 102.26,120.59 102.26,120.15 102,119.89 101.17,119.89 101.07,119.78 101.07,119.58 101.17,119.48 102,119.48 102.26,119.21 102.26,118.78 102,118.51 101.17,118.51 101.07,118.41 101.07,118.21 101.17,118.11 102,118.11 102.26,117.84 102.26,117.41 102,117.14 101.17,117.14 101.07,117.04 101.07,116.84 101.17,116.74 102,116.74 102.26,116.47 102.26,116.04 102,115.77 101.17,115.77 101.07,115.67 101.07,115.47 101.17,115.37 102,115.37 102.26,115.1 102.26,114.67 102,114.4 101.17,114.4 101.07,114.3 101.07,114.1 101.17,113.99 102,113.99 102.26,113.73 102.26,113.29 102,113.03 101.17,113.03 101.07,112.93 101.07,112.72 101.17,112.62 102,112.62 102.26,112.36 102.26,111.92 102,111.66 101.17,111.66 101.07,111.56 101.07,111.35 101.17,111.25 102,111.25 102.26,110.99 102.26,110.55 102,110.29 101.17,110.29 101.07,110.18 101.07,109.56 100.8,109.3 98.93,109.3 98.83,109.2 98.83,108.99 98.93,108.89 100.66,108.89 101.07,108.48 101.07,107.24 101.17,107.14 102,107.14 102.26,106.87 102.26,106.44 102,106.17 101.17,106.17 101.07,106.07 101.07,105.87 101.17,105.76 102,105.76 102.26,105.5 102.26,105.06 102,104.8 101.17,104.8 101.07,104.7 101.07,104.49 101.17,104.39 102,104.39 102.26,104.13 102.26,103.69 102,103.43 101.17,103.43 101.07,103.33 101.07,103.12 101.17,103.02 102,103.02 102.26,102.76 102.26,102.32 102,102.06 101.19,102.06 100.89,101.75 100.89,100.7 102.11,99.48 102.11,95.65 102.64,95.11 102.64,94.08 102.57,94.01 102.57,90.46 102.57,90.46 102.57,90.14 102.57,90.14 102.57,87.94 102.21,87.58 102.21,87.58 102.2,87.57 101.67,87.57 101.58,87.48 101.58,86.94 101.7,86.83 102.35,86.83 102.42,86.9 102.42,87.05 102.27,87.2 v2(101.95,87.2)
  BOTTOM w0.114: J3.100 95.35,149.84 95.35,148.06 v1(95.58,147.83)
INPUT24_P: length 118.6
  TOP w0.114: U5.AB8 v2(102.95,86.2)
  L10-SIG4 w0.102: v1(94.82,147.83) 95.07,147.58 95.07,143.71 100.79,138 100.79,135.93 101.05,135.66 101.8,135.66 101.9,135.56 101.9,135.36 101.8,135.25 101.05,135.25 100.79,134.99 100.79,134.55 101.05,134.29 101.88,134.29 101.98,134.19 101.98,133.98 101.88,133.88 101.05,133.88 100.79,133.62 100.79,133.18 101.05,132.92 101.88,132.92 101.98,132.81 101.98,132.61 101.88,132.51 101.05,132.51 100.79,132.24 100.79,131.81 101.05,131.54 101.88,131.54 101.98,131.44 101.98,131.24 101.88,131.14 101.05,131.14 100.79,130.87 100.79,130.44 101.05,130.17 101.88,130.17 101.98,130.07 101.98,129.87 101.88,129.77 101.05,129.77 100.79,129.5 100.79,129.07 101.05,128.8 101.88,128.8 101.98,128.7 101.98,128.5 101.88,128.4 101.05,128.4 100.79,128.13 100.79,127.7 101.05,127.43 101.88,127.43 101.98,127.33 101.98,127.13 101.88,127.02 101.05,127.02 100.79,126.76 100.79,126.32 101.05,126.06 101.88,126.06 101.98,125.96 101.98,125.75 101.88,125.65 101.05,125.65 100.79,125.39 100.79,124.95 101.05,124.69 101.88,124.69 101.98,124.59 101.98,124.38 101.88,124.28 101.05,124.28 100.79,124.02 100.79,123.58 101.05,123.32 101.88,123.32 101.98,123.21 101.98,123.01 101.88,122.91 101.05,122.91 100.79,122.64 100.79,122.21 101.05,121.94 101.88,121.94 101.98,121.84 101.98,121.64 101.88,121.54 101.05,121.54 100.79,121.27 100.79,120.84 101.05,120.57 101.88,120.57 101.98,120.47 101.98,120.27 101.88,120.17 101.05,120.17 100.79,119.9 100.79,119.47 101.05,119.2 101.88,119.2 101.98,119.1 101.98,118.9 101.88,118.79 101.05,118.79 100.79,118.53 100.79,118.09 101.05,117.83 101.88,117.83 101.98,117.73 101.98,117.52 101.88,117.42 101.05,117.42 100.79,117.16 100.79,116.72 101.05,116.46 101.88,116.46 101.98,116.36 101.98,116.15 101.88,116.05 101.05,116.05 100.79,115.79 100.79,115.35 101.05,115.09 101.88,115.09 101.98,114.98 101.98,114.78 101.88,114.68 101.05,114.68 100.79,114.41 100.79,113.98 101.05,113.71 101.88,113.71 101.98,113.61 101.98,113.41 101.88,113.31 101.05,113.31 100.79,113.04 100.79,112.61 101.05,112.34 101.88,112.34 101.98,112.24 101.98,112.04 101.88,111.94 101.05,111.94 100.79,111.67 100.79,111.24 101.05,110.97 101.88,110.97 101.98,110.87 101.98,110.67 101.88,110.56 101.05,110.56 100.79,110.3 100.79,109.68 100.69,109.58 98.82,109.58 98.55,109.31 98.55,108.84 98.78,108.61 100.42,108.61 100.79,108.24 100.79,107.12 101.05,106.86 101.88,106.86 101.98,106.75 101.98,106.55 101.88,106.45 101.05,106.45 100.79,106.18 100.79,105.75 101.05,105.48 101.88,105.48 101.98,105.38 101.98,105.18 101.88,105.08 101.05,105.08 100.79,104.81 100.79,104.38 101.05,104.11 101.88,104.11 101.98,104.01 101.98,103.81 101.88,103.71 101.05,103.71 100.79,103.44 100.79,103.01 101.05,102.74 101.88,102.74 101.98,102.64 101.98,102.44 101.88,102.33 101.05,102.33 100.61,101.89 100.61,100.58 101.83,99.36 101.83,95.53 102.36,95 102.36,94.14 102.33,94.11 102.33,90.56 102.33,90.55 102.33,90.04 102.33,90.04 102.33,88.04 102.1,87.81 101.58,87.81 101.35,87.58 101.35,86.84 101.6,86.59 102.56,86.59 v2(102.95,86.2)
  BOTTOM w0.114: J3.102 95.06,149.82 95.06,148.07 v1(94.82,147.83)
INPUT25_M: length 118.6
  TOP w0.114: U5.M8 v2(113.95,86.2)
  L4-SIG2 w0.102: v2(113.95,86.2) 113.94,86.19 113.94,85.83 114.05,85.72 114.2,85.72 114.33,85.86 114.33,95.39 113.42,96.3 109.82,96.3 107.65,98.48 107.65,99.9 103.76,103.78 103.76,104.62 103.66,104.73 102.7,104.73 102.44,104.99 102.44,105.43 102.7,105.69 103.66,105.69 103.76,105.79 103.76,106 103.66,106.1 102.7,106.1 102.44,106.36 102.44,106.8 102.7,107.06 103.66,107.06 103.76,107.16 103.76,110.11 103.66,110.21 102.7,110.21 102.44,110.48 102.44,110.91 102.7,111.18 103.66,111.18 103.76,111.28 103.76,111.48 103.66,111.58 102.7,111.58 102.44,111.85 102.44,112.28 102.7,112.55 103.66,112.55 103.76,112.65 103.76,112.85 103.66,112.96 102.7,112.96 102.44,113.22 102.44,113.66 102.7,113.92 103.66,113.92 103.76,114.02 103.76,114.23 103.66,114.33 102.7,114.33 102.44,114.59 102.44,115.03 102.7,115.29 103.66,115.29 103.76,115.39 103.76,115.6 103.66,115.7 102.7,115.7 102.44,115.96 102.44,116.4 102.7,116.66 103.66,116.66 103.76,116.77 103.76,116.97 103.66,117.07 102.7,117.07 102.44,117.34 102.44,117.77 102.7,118.04 103.66,118.04 103.76,118.14 103.76,118.34 103.66,118.44 102.7,118.44 102.44,118.71 102.44,119.14 102.7,119.41 103.66,119.41 103.76,119.51 103.76,119.71 103.66,119.81 102.7,119.81 102.44,120.08 102.44,120.51 102.7,120.78 103.66,120.78 103.76,120.88 103.76,121.08 103.66,121.19 102.7,121.19 102.44,121.45 102.44,121.89 102.7,122.15 103.66,122.15 103.76,122.25 103.76,122.46 103.66,122.56 102.7,122.56 102.44,122.82 102.44,123.26 102.7,123.52 103.66,123.52 103.76,123.62 103.76,123.83 103.66,123.93 102.7,123.93 102.44,124.19 102.44,124.63 102.7,124.89 103.66,124.89 103.76,125 103.76,125.2 103.66,125.3 102.7,125.3 102.44,125.57 102.44,126 102.7,126.27 103.66,126.27 103.76,126.37 103.76,126.57 103.66,126.67 102.7,126.67 102.44,126.94 102.44,127.37 102.7,127.64 103.66,127.64 103.76,127.74 103.76,127.94 103.66,128.04 102.7,128.04 102.44,128.31 102.44,128.85 103.48,129.89 103.48,131.15 100.52,134.12 99.69,134.12 99.38,134.42 99.38,134.8 99.95,135.36 99.95,135.51 99.8,135.65 99.66,135.65 99.1,135.09 98.72,135.09 98.41,135.39 98.41,135.77 98.98,136.33 98.98,136.48 98.83,136.62 98.69,136.62 98.13,136.06 97.75,136.06 97.44,136.36 97.44,137.19 95.21,139.42 93.75,139.42 92.91,140.26 92.91,146.13 93.37,146.58 93.37,147.62 92.89,148.11 92.89,148.56 93.12,148.79 93.6,148.79 v1(94.06,148.34)
  BOTTOM w0.114: v1(94.06,148.34) 93.83,148.57 93.83,149.82 J3.106
INPUT25_P: length 118.5
  TOP w0.114: U5.L9 v2(114.95,85.2)
  L4-SIG2 w0.102: v2(114.95,85.2) 114.57,85.58 114.57,93.95 114.61,93.99 114.61,95.5 114.31,95.8 113.54,96.58 109.94,96.58 107.92,98.59 107.92,100.01 106.59,101.35 106.59,101.49 106.68,101.58 106.68,101.73 106.54,101.87 106.39,101.87 106.3,101.78 106.16,101.78 106.01,101.92 106.01,102.07 106.1,102.16 106.1,102.3 105.96,102.45 105.82,102.45 105.73,102.36 105.58,102.36 105.44,102.5 105.44,102.64 105.53,102.73 105.53,102.88 105.39,103.02 105.24,103.02 105.15,102.93 105.01,102.93 104.86,103.07 104.86,103.22 104.96,103.31 104.96,103.45 104.81,103.6 104.67,103.6 104.58,103.51 104.43,103.51 104.04,103.9 104.04,104.74 103.77,105.01 102.82,105.01 102.72,105.11 102.72,105.31 102.82,105.41 103.77,105.41 104.04,105.68 104.04,106.11 103.77,106.38 102.82,106.38 102.72,106.48 102.72,106.68 102.82,106.78 103.77,106.78 104.04,107.05 104.04,110.23 103.77,110.49 102.82,110.49 102.72,110.59 102.72,110.8 102.82,110.9 103.77,110.9 104.04,111.16 104.04,111.6 103.77,111.86 102.82,111.86 102.72,111.97 102.72,112.17 102.82,112.27 103.77,112.27 104.04,112.54 104.04,112.97 103.77,113.24 102.82,113.24 102.72,113.34 102.72,113.54 102.82,113.64 103.77,113.64 104.04,113.91 104.04,114.34 103.77,114.61 102.82,114.61 102.72,114.71 102.72,114.91 102.82,115.01 103.77,115.01 104.04,115.28 104.04,115.71 103.77,115.98 102.82,115.98 102.72,116.08 102.72,116.28 102.82,116.38 103.77,116.38 104.04,116.65 104.04,117.08 103.77,117.35 102.82,117.35 102.72,117.45 102.72,117.65 102.82,117.76 103.77,117.76 104.04,118.02 104.04,118.46 103.77,118.72 102.82,118.72 102.72,118.82 102.72,119.03 102.82,119.13 103.77,119.13 104.04,119.39 104.04,119.83 103.77,120.09 102.82,120.09 102.72,120.19 102.72,120.4 102.82,120.5 103.77,120.5 104.04,120.76 104.04,121.2 103.77,121.46 102.82,121.46 102.72,121.57 102.72,121.77 102.82,121.87 103.77,121.87 104.04,122.14 104.04,122.57 103.77,122.84 102.82,122.84 102.72,122.94 102.72,123.14 102.82,123.24 103.77,123.24 104.04,123.51 104.04,123.94 103.77,124.21 102.82,124.21 102.72,124.31 102.72,124.51 102.82,124.61 103.77,124.61 104.04,124.88 104.04,125.31 103.77,125.58 102.82,125.58 102.72,125.68 102.72,125.88 102.82,125.99 103.77,125.99 104.04,126.25 104.04,126.69 103.77,126.95 102.82,126.95 102.72,127.05 102.72,127.26 102.82,127.36 103.77,127.36 104.04,127.62 104.04,128.06 103.77,128.32 102.82,128.32 102.72,128.42 102.72,128.74 103.76,129.78 103.76,131.27 100.63,134.4 99.81,134.4 99.66,134.54 99.66,134.68 100.23,135.25 100.23,135.62 99.92,135.93 99.55,135.93 98.98,135.37 98.84,135.37 98.69,135.51 98.69,135.65 99.26,136.22 99.26,136.59 98.95,136.9 98.58,136.9 98.01,136.34 97.87,136.34 97.72,136.48 97.72,137.3 95.33,139.7 93.87,139.7 93.19,140.37 93.19,146.01 93.65,146.47 93.65,147.98 v1(93.3,148.34)
  BOTTOM w0.114: J3.108 93.54,149.85 93.54,148.57 v1(93.3,148.34)
INPUT26_M: length 118.4
  TOP w0.114: U5.H8 v2(117.95,86.2)
  L4-SIG2 w0.102: v1(92.58,147.83) 92.3,147.55 92.3,147.03 91.74,146.47 91.74,140.3 101.27,130.77 101.27,129.18 100.31,128.23 100.18,128.23 100.08,128.13 100.08,127.92 100.18,127.82 101,127.82 101.27,127.56 101.27,127.12 101,126.86 100.18,126.86 100.08,126.76 100.08,126.55 100.18,126.45 101,126.45 101.27,126.19 101.27,125.75 101,125.49 100.18,125.49 100.08,125.38 100.08,125.18 100.18,125.08 101,125.08 101.27,124.81 101.27,124.38 101,124.11 100.18,124.11 100.08,124.01 100.08,123.81 100.18,123.71 101,123.71 101.27,123.44 101.27,123.01 101,122.74 100.18,122.74 100.08,122.64 100.08,122.44 100.18,122.34 101,122.34 101.27,122.07 101.27,121.64 101,121.37 100.18,121.37 100.08,121.27 100.08,121.07 100.18,120.96 101,120.96 101.27,120.7 101.27,120.26 101,120 100.18,120 100.08,119.9 100.08,119.69 100.18,119.59 101,119.59 101.27,119.33 101.27,118.89 101,118.63 100.18,118.63 100.08,118.53 100.08,118.32 100.18,118.22 101,118.22 101.27,117.96 101.27,117.52 101,117.26 100.18,117.26 100.08,117.15 100.08,116.95 100.18,116.85 101,116.85 101.27,116.58 101.27,116.15 101,115.88 100.18,115.88 100.08,115.78 100.08,115.58 100.18,115.48 101,115.48 101.27,115.21 101.27,114.78 101,114.51 100.18,114.51 100.08,114.41 100.08,114.21 100.18,114.11 101,114.11 101.27,113.84 101.27,113.41 101,113.14 100.18,113.14 100.08,113.04 100.08,112.84 100.18,112.73 101,112.73 101.27,112.47 101.27,112.03 101,111.77 100.18,111.77 100.08,111.67 100.08,111.46 100.18,111.36 101,111.36 101.27,111.1 101.27,110.66 101,110.4 100.18,110.4 100.08,110.3 100.08,110.09 100.18,109.99 101,109.99 101.27,109.73 101.27,109.29 101,109.03 100.18,109.03 100.08,108.92 100.08,108.72 100.18,108.62 101,108.62 101.27,108.35 101.27,107.92 101,107.65 100.18,107.65 100.08,107.55 100.08,107.35 100.18,107.25 101,107.25 101.27,106.98 101.27,106.55 101,106.28 100.18,106.28 100.08,106.18 100.08,105.98 100.18,105.88 101,105.88 101.27,105.61 101.27,105.18 101,104.91 100.18,104.91 100.08,104.81 100.08,104.61 100.18,104.5 101,104.5 101.27,104.24 101.27,103.54 105.92,98.9 105.92,98.57 107.24,97.25 107.24,96.66 109.39,94.51 112.83,94.51 113.57,93.77 113.57,93.36 113.57,93.36 113.57,93.04 113.57,93.04 113.57,92.36 113.57,92.36 113.57,92.04 113.57,92.04 113.57,91.36 113.57,91.36 113.57,91.04 113.57,91.04 113.57,90.36 113.57,90.36 113.57,90.04 113.57,90.04 113.57,89.36 113.57,89.36 113.57,89.04 113.57,89.04 113.57,88.36 113.57,88.36 113.57,86.14 113.57,86.14 113.57,85.36 113.57,85.36 113.57,85.04 113.79,84.82 118.11,84.82 118.29,84.82 118.33,84.86 118.33,85.04 118.33,85.04 118.33,85.82 v2(117.95,86.2)
  BOTTOM w0.114: v1(92.58,147.83) 92.33,148.08 92.33,149.82 J3.112
INPUT26_P: length 118.6
  TOP w0.114: U5.G9 v2(118.95,85.2)
  L4-SIG2 w0.102: v2(118.95,85.2) 118.76,85.39 118.62,85.39 118.57,85.35 118.57,84.94 118.57,84.94 118.57,84.76 118.39,84.58 118.21,84.58 118.21,84.58 113.69,84.58 113.33,84.94 113.33,85.46 113.33,85.46 113.33,86.04 113.33,86.04 113.33,89.46 113.33,89.46 113.33,89.94 113.33,89.94 113.33,90.46 113.33,90.46 113.33,90.94 113.33,90.94 113.33,91.46 113.33,91.46 113.33,91.94 113.33,91.94 113.33,92.46 113.33,92.46 113.33,92.94 113.33,92.94 113.33,93.46 113.33,93.46 113.33,93.67 113.09,93.91 113.04,93.91 112.71,94.23 109.27,94.23 106.96,96.55 106.96,97.13 105.64,98.45 105.64,98.78 100.99,103.43 100.99,104.12 100.89,104.23 100.06,104.23 99.8,104.49 99.8,104.93 100.06,105.19 100.89,105.19 100.99,105.29 100.99,105.5 100.89,105.6 100.06,105.6 99.8,105.86 99.8,106.3 100.06,106.56 100.89,106.56 100.99,106.66 100.99,106.87 100.89,106.97 100.06,106.97 99.8,107.23 99.8,107.67 100.06,107.93 100.89,107.93 100.99,108.04 100.99,108.24 100.89,108.34 100.06,108.34 99.8,108.61 99.8,109.04 100.06,109.31 100.89,109.31 100.99,109.41 100.99,109.61 100.89,109.71 100.06,109.71 99.8,109.98 99.8,110.41 100.06,110.68 100.89,110.68 100.99,110.78 100.99,110.98 100.89,111.08 100.06,111.08 99.8,111.35 99.8,111.78 100.06,112.05 100.89,112.05 100.99,112.15 100.99,112.35 100.89,112.46 100.06,112.46 99.8,112.72 99.8,113.15 100.06,113.42 100.89,113.42 100.99,113.52 100.99,113.73 100.89,113.83 100.06,113.83 99.8,114.09 99.8,114.53 100.06,114.79 100.89,114.79 100.99,114.89 100.99,115.1 100.89,115.2 100.06,115.2 99.8,115.46 99.8,115.9 100.06,116.16 100.89,116.16 100.99,116.27 100.99,116.47 100.89,116.57 100.06,116.57 99.8,116.84 99.8,117.27 100.06,117.54 100.89,117.54 100.99,117.64 100.99,117.84 100.89,117.94 100.06,117.94 99.8,118.21 99.8,118.64 100.06,118.91 100.89,118.91 100.99,119.01 100.99,119.21 100.89,119.31 100.06,119.31 99.8,119.58 99.8,120.01 100.06,120.28 100.89,120.28 100.99,120.38 100.99,120.58 100.89,120.68 100.06,120.68 99.8,120.95 99.8,121.38 100.06,121.65 100.89,121.65 100.99,121.75 100.99,121.95 100.89,122.06 100.06,122.06 99.8,122.32 99.8,122.76 100.06,123.02 100.89,123.02 100.99,123.12 100.99,123.33 100.89,123.43 100.06,123.43 99.8,123.69 99.8,124.13 100.06,124.39 100.89,124.39 100.99,124.49 100.99,124.7 100.89,124.8 100.06,124.8 99.8,125.06 99.8,125.5 100.06,125.76 100.89,125.76 100.99,125.87 100.99,126.07 100.89,126.17 100.06,126.17 99.8,126.44 99.8,126.87 100.06,127.14 100.89,127.14 100.99,127.24 100.99,127.44 100.89,127.54 100.06,127.54 99.8,127.81 99.8,128.24 100.06,128.51 100.16,128.51 100.99,129.34 100.99,130.66 91.47,140.18 91.47,146.58 92.02,147.14 92.02,147.62 v1(91.82,147.83)
  BOTTOM w0.114: J3.114 92.04,149.85 92.04,148.04 v1(91.82,147.83)
INPUT27_M: length 118.5
  TOP w0.114: U5.M30 v2(113.95,63.2)
  L9-SIG3 w0.102: v1(91.08,147.7) 91.08,147.75 90.91,147.93 90.91,148.25 90.62,148.54 90.11,148.54 89.59,148.02 89.59,146.86 90.55,145.9 90.55,140.92 92.41,139.06 92.41,138.07 100.74,129.74 100.74,125.97 100.41,125.64 100.41,125.21 100.67,124.94 100.81,124.94 100.97,124.79 100.97,124.64 100.86,124.54 100.67,124.54 100.41,124.27 100.41,123.84 100.67,123.57 100.97,123.57 101.07,123.47 101.07,123.27 100.97,123.16 100.67,123.16 100.41,122.9 100.41,122.46 100.67,122.2 100.97,122.2 101.07,122.1 101.07,121.89 100.97,121.79 100.67,121.79 100.41,121.53 100.41,121.09 100.67,120.83 100.97,120.83 101.07,120.73 101.07,120.52 100.97,120.42 100.67,120.42 100.41,120.16 100.41,119.72 100.67,119.46 100.97,119.46 101.07,119.35 101.07,119.15 100.97,119.05 100.67,119.05 100.41,118.78 100.41,118.35 100.67,118.08 100.97,118.08 101.07,117.98 101.07,117.78 100.97,117.68 100.67,117.68 100.41,117.41 100.41,116.98 100.67,116.71 100.97,116.71 101.07,116.61 101.07,116.41 100.97,116.31 100.67,116.31 100.41,116.04 100.41,115.61 100.67,115.34 100.97,115.34 101.07,115.24 101.07,115.04 100.97,114.94 100.67,114.94 100.41,114.67 100.41,114.24 100.67,113.97 100.97,113.97 101.07,113.87 101.07,113.67 100.97,113.56 100.67,113.56 100.41,113.3 100.41,112.86 100.67,112.6 100.97,112.6 101.07,112.5 101.07,112.29 100.97,112.19 100.67,112.19 100.41,111.93 100.41,111.49 100.67,111.23 100.97,111.23 101.07,111.13 101.07,110.92 100.97,110.82 100.67,110.82 100.41,110.56 100.41,110.12 100.67,109.86 100.97,109.86 101.07,109.75 101.07,109.55 100.97,109.45 100.67,109.45 100.41,109.18 100.41,108.75 100.67,108.48 100.97,108.48 101.07,108.38 101.07,108.18 100.97,108.08 100.67,108.08 100.41,107.81 100.41,107.38 100.67,107.11 100.97,107.11 101.07,107.01 101.07,106.81 100.97,106.71 100.67,106.71 100.41,106.44 100.41,106.01 100.67,105.74 100.97,105.74 101.07,105.64 101.07,105.44 100.97,105.33 100.67,105.33 100.41,105.07 100.41,104.63 100.67,104.37 100.97,104.37 101.07,104.27 101.07,104.03 100.74,103.7 100.74,101.7 103.71,98.73 103.71,97.79 106.15,95.35 106.15,93.76 106.33,93.58 106.33,93.04 106.32,93.04 106.32,92.36 106.33,92.36 106.33,92.04 106.32,92.04 106.32,89.36 106.33,89.36 106.33,89.04 106.32,89.04 106.32,88.36 106.33,88.36 106.33,88.04 106.32,88.04 106.32,87.36 106.33,87.36 106.33,87.04 106.32,87.04 106.32,86.36 106.33,86.36 106.33,86.04 106.32,86.04 106.32,85.36 106.33,85.36 106.33,85.04 106.32,85.04 106.32,84.36 106.33,84.36 106.33,84.04 106.32,84.04 106.32,83.36 106.33,83.36 106.33,83.04 106.32,83.04 106.32,82.36 106.33,82.36 106.33,82.04 106.32,82.04 106.32,81.36 106.33,81.36 106.33,81.04 106.32,81.04 106.32,80.36 106.33,80.36 106.33,80.04 106.32,80.04 106.32,79.36 106.33,79.36 106.33,79.04 106.32,79.04 106.32,78.36 106.33,78.36 106.33,78.04 106.32,78.04 106.32,77.36 106.33,77.36 106.33,77.04 106.32,77.04 106.32,75.36 106.33,75.36 106.33,75.04 106.32,75.04 106.32,74.36 106.33,74.36 106.33,74.04 106.32,74.04 106.32,73.36 106.33,73.36 106.33,73.04 106.32,73.04 106.32,72.36 106.33,72.36 106.33,72.04 106.32,72.04 106.32,71.36 106.33,71.36 106.33,71.04 106.32,71.04 106.32,70.36 106.33,70.36 106.33,70.04 106.32,70.04 106.32,69.36 106.33,69.36 106.33,69.04 106.32,69.04 106.32,68.36 106.33,68.36 106.33,67.94 106.69,67.58 108.7,67.58 109.33,66.95 109.33,63.94 109.69,63.58 113.22,63.58 113.23,63.57 114.21,63.57 114.34,63.43 114.34,63.29 114.25,63.2 v2(113.95,63.2)
  BOTTOM w0.114: J3.118 90.86,149.85 90.86,148.54 91.06,148.34 91.06,147.73 v1(91.08,147.7)
INPUT27_P: length 118.4
  TOP w0.114: U5.L29 v2(114.95,64.2)
  L9-SIG3 w0.102: v2(114.95,64.2) 114.55,63.8 114.4,63.8 114.39,63.82 109.79,63.82 109.57,64.04 109.57,67.04 108.79,67.82 106.79,67.82 106.57,68.04 106.57,68.46 106.56,68.46 106.56,68.94 106.57,68.94 106.57,69.46 106.56,69.46 106.56,69.94 106.57,69.94 106.57,70.46 106.56,70.46 106.56,70.94 106.57,70.94 106.57,71.46 106.56,71.46 106.56,71.94 106.57,71.94 106.57,72.46 106.56,72.46 106.56,72.94 106.57,72.94 106.57,73.46 106.56,73.46 106.56,73.94 106.57,73.94 106.57,74.46 106.56,74.46 106.56,74.94 106.57,74.94 106.57,75.46 106.56,75.46 106.56,76.94 106.57,76.94 106.57,77.46 106.56,77.46 106.56,77.94 106.57,77.94 106.57,78.46 106.56,78.46 106.56,78.94 106.57,78.94 106.57,79.46 106.56,79.46 106.56,79.94 106.57,79.94 106.57,80.46 106.56,80.46 106.56,80.94 106.57,80.94 106.57,81.46 106.56,81.46 106.56,81.94 106.57,81.94 106.57,82.46 106.56,82.46 106.56,82.94 106.57,82.94 106.57,83.46 106.56,83.46 106.56,83.94 106.57,83.94 106.57,84.46 106.56,84.46 106.56,84.94 106.57,84.94 106.57,85.46 106.56,85.46 106.56,85.94 106.57,85.94 106.57,86.46 106.56,86.46 106.56,86.94 106.57,86.94 106.57,87.46 106.56,87.46 106.56,87.94 106.57,87.94 106.57,88.46 106.56,88.46 106.56,88.94 106.57,88.94 106.57,89.46 106.56,89.46 106.56,91.94 106.57,91.94 106.57,92.46 106.56,92.46 106.56,92.94 106.57,92.94 106.57,93.68 106.38,93.86 106.38,94.07 106.43,94.11 106.43,95.47 103.99,97.91 103.99,98.85 101.02,101.82 101.02,103.58 101.35,103.91 101.35,104.38 101.08,104.65 100.79,104.65 100.69,104.75 100.69,104.95 100.79,105.05 101.08,105.05 101.35,105.32 101.35,105.75 101.08,106.02 100.79,106.02 100.69,106.12 100.69,106.32 100.79,106.43 101.08,106.43 101.35,106.69 101.35,107.13 101.08,107.39 100.79,107.39 100.69,107.49 100.69,107.7 100.79,107.8 101.08,107.8 101.35,108.06 101.35,108.5 101.08,108.76 100.79,108.76 100.69,108.86 100.69,109.07 100.79,109.17 101.08,109.17 101.35,109.43 101.35,109.87 101.08,110.13 100.79,110.13 100.69,110.24 100.69,110.44 100.79,110.54 101.08,110.54 101.35,110.81 101.35,111.24 101.08,111.51 100.79,111.51 100.69,111.61 100.69,111.81 100.79,111.91 101.08,111.91 101.35,112.18 101.35,112.61 101.08,112.88 100.79,112.88 100.69,112.98 100.69,113.18 100.79,113.28 101.08,113.28 101.35,113.55 101.35,113.98 101.08,114.25 100.79,114.25 100.69,114.35 100.69,114.55 100.79,114.66 101.08,114.66 101.35,114.92 101.35,115.36 101.08,115.62 100.79,115.62 100.69,115.72 100.69,115.93 100.79,116.03 101.08,116.03 101.35,116.29 101.35,116.73 101.08,116.99 100.79,116.99 100.69,117.09 100.69,117.3 100.79,117.4 101.08,117.4 101.35,117.66 101.35,118.1 101.08,118.36 100.79,118.36 100.69,118.47 100.69,118.67 100.79,118.77 101.08,118.77 101.35,119.04 101.35,119.47 101.08,119.74 100.79,119.74 100.69,119.84 100.69,120.04 100.79,120.14 101.08,120.14 101.35,120.41 101.35,120.84 101.08,121.11 100.79,121.11 100.69,121.21 100.69,121.41 100.79,121.51 101.08,121.51 101.35,121.78 101.35,122.21 101.08,122.48 100.79,122.48 100.69,122.58 100.69,122.78 100.79,122.89 101.08,122.89 101.35,123.15 101.35,123.59 101.08,123.85 100.79,123.85 100.69,123.95 100.69,124.16 100.79,124.26 101.08,124.26 101.35,124.52 101.35,124.96 101.08,125.22 100.79,125.22 100.69,125.32 100.69,125.53 101.02,125.86 101.02,126.11 101.12,126.21 101.19,126.21 101.3,126.31 101.3,126.51 101.19,126.62 101.12,126.62 101.02,126.72 101.02,126.92 101.12,127.02 101.19,127.02 101.3,127.12 101.3,127.33 101.19,127.43 101.12,127.43 101.02,127.53 101.02,129.86 92.68,138.19 92.68,139.18 90.83,141.03 90.83,146.01 89.87,146.98 89.87,147.9 90.22,148.26 90.5,148.26 90.63,148.13 90.63,147.93 90.53,147.83 90.45,147.83 v1(90.32,147.7)
  BOTTOM w0.114: J3.120 90.56,149.82 90.56,148.6 90.3,148.34 90.3,147.73 v1(90.32,147.7)
INPUT28_M: length 118.6
  TOP w0.114: U5.K30 v2(115.95,63.2)
  L9-SIG3 w0.102: v1(104.54,141.96) 104.31,141.73 104.29,141.73 104.19,141.63 104.19,140.93 104.24,140.88 104.24,139.29 109.98,133.55 109.98,124.19 109.72,123.93 109.6,123.93 109.45,123.77 109.45,123.65 109.57,123.52 110.28,123.52 110.54,123.26 110.54,122.82 110.28,122.56 109.52,122.56 109.42,122.46 109.42,122.25 109.52,122.15 110.28,122.15 110.54,121.89 110.54,121.45 110.28,121.19 109.52,121.19 109.42,121.08 109.42,120.88 109.52,120.78 110.28,120.78 110.54,120.51 110.54,120.08 110.28,119.81 109.52,119.81 109.42,119.71 109.42,119.51 109.52,119.41 110.28,119.41 110.54,119.14 110.54,118.71 110.28,118.44 109.52,118.44 109.42,118.34 109.42,118.14 109.52,118.04 110.28,118.04 110.54,117.77 110.54,117.34 110.28,117.07 109.52,117.07 109.42,116.97 109.42,116.77 109.52,116.66 110.28,116.66 110.54,116.4 110.54,115.96 110.28,115.7 109.52,115.7 109.42,115.6 109.42,115.39 109.52,115.29 110.28,115.29 110.54,115.03 110.54,114.59 110.28,114.33 109.52,114.33 109.42,114.23 109.42,114.02 109.52,113.92 110.28,113.92 110.54,113.66 110.54,113.22 110.28,112.96 109.52,112.96 109.42,112.85 109.42,112.65 109.52,112.55 110.28,112.55 110.54,112.28 110.54,111.85 110.28,111.58 109.52,111.58 109.42,111.48 109.42,111.28 109.52,111.18 110.28,111.18 110.54,110.91 110.54,110.48 110.28,110.21 109.52,110.21 109.42,110.11 109.42,109.91 109.52,109.81 110.28,109.81 110.54,109.54 110.54,109.11 110.28,108.84 109.52,108.84 109.42,108.74 109.42,108.54 109.52,108.43 110.28,108.43 110.54,108.17 110.54,107.73 110.28,107.47 109.52,107.47 109.42,107.37 109.42,107.16 109.52,107.06 110.28,107.06 110.54,106.8 110.54,106.36 110.28,106.1 109.52,106.1 109.42,106 109.42,105.87 109.6,105.69 110.28,105.69 110.54,105.43 110.54,104.99 110.28,104.73 110.28,104.69 109.98,104.39 109.98,97.82 108.66,96.49 108.66,94 108.53,93.87 108.53,85.49 108.57,85.46 108.57,84.94 108.49,84.87 108.49,70.12 108.79,69.82 113.21,69.82 113.57,69.46 113.57,68.94 113.52,68.9 113.52,68.5 113.57,68.46 113.57,67.94 113.52,67.9 113.52,67.5 113.57,67.46 113.57,66.94 113.54,66.91 113.54,66.49 113.57,66.46 113.57,65.92 113.67,65.82 116.27,65.82 116.72,65.37 116.72,63.99 116.3,63.57 115.68,63.57 115.57,63.46 115.57,63.27 115.64,63.2 v2(115.95,63.2)
  BOTTOM w0.114: J3.63 104.39,144.14 104.39,142.93 104.47,142.86 104.47,142.04 104.54,141.97 v1(104.54,141.96)
INPUT28_P: length 118.5
  TOP w0.114: U5.L30 v2(114.95,63.2)
  L9-SIG3 w0.102: v1(104.04,142.52) 103.91,142.39 103.91,140.82 103.96,140.77 103.96,139.17 109.7,133.43 109.7,124.31 109.6,124.21 109.41,124.21 109.14,123.94 109.14,123.51 109.41,123.24 110.16,123.24 110.26,123.14 110.26,122.94 110.16,122.84 109.41,122.84 109.14,122.57 109.14,122.14 109.41,121.87 110.16,121.87 110.26,121.77 110.26,121.57 110.16,121.46 109.41,121.46 109.14,121.2 109.14,120.76 109.41,120.5 110.16,120.5 110.26,120.4 110.26,120.19 110.16,120.09 109.41,120.09 109.14,119.83 109.14,119.39 109.41,119.13 110.16,119.13 110.26,119.03 110.26,118.82 110.16,118.72 109.41,118.72 109.14,118.46 109.14,118.02 109.41,117.76 110.16,117.76 110.26,117.65 110.26,117.45 110.16,117.35 109.41,117.35 109.14,117.08 109.14,116.65 109.41,116.38 110.16,116.38 110.26,116.28 110.26,116.08 110.16,115.98 109.41,115.98 109.14,115.71 109.14,115.28 109.41,115.01 110.16,115.01 110.26,114.91 110.26,114.71 110.16,114.61 109.41,114.61 109.14,114.34 109.14,113.91 109.41,113.64 110.16,113.64 110.26,113.54 110.26,113.34 110.16,113.24 109.41,113.24 109.14,112.97 109.14,112.54 109.41,112.27 110.16,112.27 110.26,112.17 110.26,111.97 110.16,111.86 109.41,111.86 109.14,111.6 109.14,111.16 109.41,110.9 110.16,110.9 110.26,110.8 110.26,110.59 110.16,110.49 109.41,110.49 109.14,110.23 109.14,109.79 109.41,109.53 110.16,109.53 110.26,109.43 110.26,109.22 110.16,109.12 109.41,109.12 109.14,108.86 109.14,108.42 109.41,108.16 110.16,108.16 110.26,108.05 110.26,107.85 110.16,107.75 109.41,107.75 109.14,107.48 109.14,107.05 109.41,106.78 110.16,106.78 110.26,106.68 110.26,106.48 110.16,106.38 109.41,106.38 109.14,106.11 109.14,105.68 109.41,105.41 110.16,105.41 110.26,105.31 110.26,105.11 110.16,105.01 110.09,105.01 109.7,104.62 109.7,97.93 108.38,96.61 108.38,94.12 108.3,94.03 108.3,85.39 108.33,85.36 108.33,85.04 108.25,84.97 108.25,70.02 108.69,69.58 113.11,69.58 113.33,69.36 113.33,69.04 113.28,69 113.28,68.4 113.33,68.36 113.33,68.04 113.28,68 113.28,67.4 113.33,67.36 113.33,67.04 113.3,67.01 113.3,66.39 113.33,66.36 113.33,66.04 113.28,66 113.28,65.86 113.57,65.58 116.18,65.58 116.48,65.27 116.48,64.08 116.2,63.8 115.58,63.8 115.37,63.59 115.34,63.59 v2(114.95,63.2)
  BOTTOM w0.114: v1(104.04,142.52) 103.99,142.57 103.99,144.15 J3.65
INPUT29_M: length 118.5
  TOP w0.114: U5.G8 v2(118.95,86.2)
  L4-SIG2 w0.102: v2(118.95,86.2) 119.35,85.8 120.12,85.8 120.33,86.02 120.33,87.36 120.32,87.37 120.32,88.03 120.33,88.04 120.33,88.36 120.32,88.37 120.32,89.03 120.33,89.04 120.33,89.36 120.32,89.37 120.32,90.03 120.33,90.04 120.33,90.36 120.32,90.37 120.32,91.03 120.33,91.04 120.33,91.36 120.32,91.37 120.32,92.03 120.33,92.04 120.33,92.36 120.32,92.37 120.32,93.03 120.33,93.04 120.33,93.36 120.32,93.37 120.32,93.95 120.28,93.99 120.28,95.98 119.52,96.73 119.46,96.8 118.52,97.73 117.81,98.45 117.81,100.27 114.75,103.32 114.61,103.32 114.53,103.24 114.38,103.24 114.24,103.39 114.24,103.53 114.32,103.61 114.32,103.75 114.18,103.89 114.03,103.89 113.95,103.82 113.81,103.82 113.67,103.96 113.67,104.1 113.74,104.18 113.74,104.33 113.6,104.47 113.46,104.47 113.38,104.39 113.24,104.39 113.09,104.54 113.09,104.68 113.17,104.76 113.17,104.9 113.03,105.04 112.88,105.04 112.8,104.97 112.66,104.97 112.52,105.11 112.52,105.25 112.59,105.33 112.59,105.48 112.45,105.62 112.31,105.62 112.23,105.54 112.09,105.54 111.94,105.69 111.94,105.83 112.02,105.91 112.02,106.05 111.83,106.24 111.81,106.24 111.53,106.53 111.53,106.96 111.78,107.21 113.04,107.21 113.14,107.31 113.14,107.51 113.04,107.62 111.63,107.62 111.36,107.88 111.36,108.32 111.63,108.58 113.04,108.58 113.14,108.68 113.14,108.89 113.04,108.99 111.63,108.99 111.36,109.25 111.36,109.69 111.63,109.95 113.04,109.95 113.14,110.05 113.14,110.26 113.04,110.36 111.63,110.36 111.36,110.62 111.36,111.06 111.63,111.32 113.04,111.32 113.14,111.43 113.14,111.63 113.04,111.73 111.63,111.73 111.36,112 111.36,112.43 111.63,112.7 113.04,112.7 113.14,112.8 113.14,113 113.04,113.1 111.63,113.1 111.36,113.37 111.36,113.8 111.63,114.07 113.04,114.07 113.14,114.17 113.14,114.37 113.04,114.47 111.63,114.47 111.36,114.74 111.36,115.17 111.63,115.44 113.04,115.44 113.14,115.54 113.14,115.74 113.04,115.85 111.63,115.85 111.36,116.11 111.36,116.55 111.63,116.81 113.04,116.81 113.14,116.91 113.14,117.12 113.04,117.22 111.63,117.22 111.36,117.48 111.36,117.92 111.63,118.18 113.04,118.18 113.14,118.28 113.14,118.49 113.04,118.59 111.63,118.59 111.36,118.85 111.36,119.29 111.63,119.55 113.04,119.55 113.14,119.66 113.14,119.86 113.04,119.96 111.63,119.96 111.36,120.23 111.36,120.66 111.63,120.93 113.04,120.93 113.14,121.03 113.14,121.23 113.04,121.33 111.63,121.33 111.36,121.6 111.36,122.03 111.63,122.3 113.04,122.3 113.14,122.4 113.14,122.6 113.04,122.7 111.63,122.7 111.36,122.97 111.36,123.4 111.63,123.67 113.04,123.67 113.14,123.77 113.14,123.97 113.04,124.08 111.63,124.08 111.36,124.34 111.36,124.78 111.63,125.04 113.04,125.04 113.14,125.14 113.14,125.35 113.04,125.45 111.63,125.45 111.36,125.71 111.36,126.15 111.63,126.41 113.04,126.41 113.14,126.51 113.14,126.72 113.04,126.82 111.63,126.82 111.36,127.08 111.36,127.52 111.63,127.78 112.71,127.78 112.99,128.07 112.99,129.41 103.28,139.13 103.28,140.42 v1(103.11,140.59)
  BOTTOM w0.114: J3.69 102.84,144.09 102.84,140.85 v1(103.11,140.59)
INPUT29_P: length 118.6
  TOP w0.114: U5.F9 v2(119.95,85.2)
  L4-SIG2 w0.102: v2(119.95,85.2) 119.92,85.17 119.58,85.17 119.52,85.23 119.52,85.45 119.61,85.55 120.22,85.55 120.57,85.9 120.57,87.46 120.56,87.47 120.56,87.93 120.57,87.94 120.57,88.46 120.56,88.47 120.56,88.93 120.57,88.94 120.57,89.46 120.56,89.47 120.56,89.93 120.57,89.94 120.57,90.46 120.56,90.47 120.56,90.93 120.57,90.94 120.57,91.46 120.56,91.47 120.56,91.93 120.57,91.94 120.57,92.46 120.56,92.47 120.56,92.93 120.57,92.94 120.57,93.46 120.56,93.47 120.56,96.09 119.72,96.93 119.66,96.99 118.72,97.93 118.08,98.57 118.08,100.38 111.81,106.65 111.81,106.83 111.91,106.93 113.15,106.93 113.42,107.2 113.42,107.63 113.15,107.9 111.74,107.9 111.64,108 111.64,108.2 111.74,108.3 113.15,108.3 113.42,108.57 113.42,109 113.15,109.27 111.74,109.27 111.64,109.37 111.64,109.57 111.74,109.67 113.15,109.67 113.42,109.94 113.42,110.37 113.15,110.64 111.74,110.64 111.64,110.74 111.64,110.94 111.74,111.05 113.15,111.05 113.42,111.31 113.42,111.75 113.15,112.01 111.74,112.01 111.64,112.11 111.64,112.32 111.74,112.42 113.15,112.42 113.42,112.68 113.42,113.12 113.15,113.38 111.74,113.38 111.64,113.48 111.64,113.69 111.74,113.79 113.15,113.79 113.42,114.05 113.42,114.49 113.15,114.75 111.74,114.75 111.64,114.86 111.64,115.06 111.74,115.16 113.15,115.16 113.42,115.43 113.42,115.86 113.15,116.13 111.74,116.13 111.64,116.23 111.64,116.43 111.74,116.53 113.15,116.53 113.42,116.8 113.42,117.23 113.15,117.5 111.74,117.5 111.64,117.6 111.64,117.8 111.74,117.9 113.15,117.9 113.42,118.17 113.42,118.6 113.15,118.87 111.74,118.87 111.64,118.97 111.64,119.17 111.74,119.28 113.15,119.28 113.42,119.54 113.42,119.98 113.15,120.24 111.74,120.24 111.64,120.34 111.64,120.55 111.74,120.65 113.15,120.65 113.42,120.91 113.42,121.35 113.15,121.61 111.74,121.61 111.64,121.71 111.64,121.92 111.74,122.02 113.15,122.02 113.42,122.28 113.42,122.72 113.15,122.98 111.74,122.98 111.64,123.09 111.64,123.29 111.74,123.39 113.15,123.39 113.42,123.66 113.42,124.09 113.15,124.36 111.74,124.36 111.64,124.46 111.64,124.66 111.74,124.76 113.15,124.76 113.42,125.03 113.42,125.46 113.15,125.73 111.74,125.73 111.64,125.83 111.64,126.03 111.74,126.13 113.15,126.13 113.42,126.4 113.42,126.83 113.15,127.1 111.74,127.1 111.64,127.2 111.64,127.4 111.74,127.5 112.82,127.5 113.27,127.96 113.27,129.52 103.56,139.24 103.56,140.77 103.3,141.02 102.72,141.02 v1(102.28,140.59)
  BOTTOM w0.114: v1(102.28,140.59) 102.55,140.86 102.55,144.09 J3.71
INPUT30_M: length 118.4
  TOP w0.114: U5.G6 v2(118.95,88.2)
  L4-SIG2 w0.102: v1(101.6,141.96) 101.33,141.69 101.33,141.35 101.08,141.1 99.01,141.1 98.7,140.79 98.7,138.68 107.01,130.38 107.01,129.92 106.01,128.92 105.79,128.92 105.69,128.82 105.69,128.61 105.79,128.51 107.05,128.51 107.31,128.25 107.31,127.81 107.05,127.55 105.79,127.55 105.69,127.45 105.69,127.24 105.79,127.14 107.05,127.14 107.31,126.88 107.31,126.44 107.05,126.18 105.79,126.18 105.69,126.07 105.69,125.87 105.79,125.77 107.05,125.77 107.31,125.5 107.31,125.07 107.05,124.8 105.79,124.8 105.69,124.7 105.69,124.5 105.79,124.4 107.05,124.4 107.31,124.13 107.31,123.7 107.05,123.43 105.79,123.43 105.69,123.33 105.69,123.13 105.79,123.03 107.05,123.03 107.31,122.76 107.31,122.33 107.05,122.06 105.79,122.06 105.69,121.96 105.69,121.76 105.79,121.66 107.05,121.66 107.31,121.39 107.31,120.96 107.05,120.69 105.79,120.69 105.69,120.59 105.69,120.39 105.79,120.28 107.05,120.28 107.31,120.02 107.31,119.58 107.05,119.32 105.79,119.32 105.69,119.22 105.69,119.01 105.79,118.91 107.05,118.91 107.31,118.65 107.31,118.21 107.05,117.95 105.79,117.95 105.69,117.85 105.69,117.64 105.79,117.54 107.05,117.54 107.31,117.28 107.31,116.84 107.05,116.58 105.79,116.58 105.69,116.47 105.69,116.27 105.79,116.17 107.05,116.17 107.31,115.9 107.31,115.47 107.05,115.2 105.79,115.2 105.69,115.1 105.69,114.9 105.79,114.8 107.05,114.8 107.31,114.53 107.31,114.1 107.05,113.83 105.79,113.83 105.69,113.73 105.69,113.53 105.79,113.43 107.05,113.43 107.31,113.16 107.31,112.73 107.05,112.46 105.79,112.46 105.69,112.36 105.69,112.16 105.79,112.05 107.05,112.05 107.31,111.79 107.31,111.35 107.05,111.09 105.79,111.09 105.69,110.99 105.69,110.78 105.79,110.68 107.05,110.68 107.31,110.42 107.31,109.98 107.05,109.72 105.79,109.72 105.69,109.62 105.69,109.41 105.79,109.31 107.05,109.31 107.31,109.05 107.31,108.61 107.05,108.35 105.79,108.35 105.69,108.24 105.69,108.04 105.79,107.94 107.05,107.94 107.31,107.67 107.31,107.24 107.05,106.97 105.79,106.97 105.69,106.87 105.69,106.67 105.79,106.57 107.05,106.57 107.31,106.3 107.31,105.87 107.05,105.6 106.6,105.6 106.5,105.5 106.5,104.67 106.86,104.32 107,104.32 107.04,104.35 107.18,104.35 107.33,104.21 107.33,104.06 107.29,104.03 107.29,103.88 107.44,103.74 107.58,103.74 107.61,103.77 107.76,103.77 107.9,103.63 107.9,103.49 107.87,103.45 107.87,103.31 113.57,97.61 115.55,97.61 116.36,96.8 116.36,95.33 116.69,95 117.59,95 118.52,94.07 118.52,93.51 118.57,93.46 118.57,88.04 118.63,87.98 118.73,87.98 v2(118.95,88.2)
  BOTTOM w0.114: v1(101.6,141.96) 101.6,141.99 101.36,142.23 101.36,144.11 J3.75
INPUT30_P: length 118.6
  TOP w0.114: U5.G7 v2(118.95,87.2)
  L4-SIG2 w0.102: v2(118.95,87.2) 118.84,87.2 118.33,87.71 118.33,93.36 118.24,93.45 118.24,93.96 117.48,94.72 116.57,94.72 116.08,95.21 116.08,96.68 115.44,97.33 113.45,97.33 106.22,104.56 106.22,105.62 106.49,105.88 106.93,105.88 107.04,105.98 107.04,106.19 106.93,106.29 105.68,106.29 105.41,106.55 105.41,106.99 105.68,107.25 106.93,107.25 107.04,107.36 107.04,107.56 106.93,107.66 105.68,107.66 105.41,107.93 105.41,108.36 105.68,108.63 106.93,108.63 107.04,108.73 107.04,108.93 106.93,109.03 105.68,109.03 105.41,109.3 105.41,109.73 105.68,110 106.93,110 107.04,110.1 107.04,110.3 106.93,110.4 105.68,110.4 105.41,110.67 105.41,111.1 105.68,111.37 106.93,111.37 107.04,111.47 107.04,111.67 106.93,111.77 105.68,111.77 105.41,112.04 105.41,112.47 105.68,112.74 106.93,112.74 107.04,112.84 107.04,113.04 106.93,113.15 105.68,113.15 105.41,113.41 105.41,113.85 105.68,114.11 106.93,114.11 107.04,114.21 107.04,114.42 106.93,114.52 105.68,114.52 105.41,114.78 105.41,115.22 105.68,115.48 106.93,115.48 107.04,115.58 107.04,115.79 106.93,115.89 105.68,115.89 105.41,116.15 105.41,116.59 105.68,116.85 106.93,116.85 107.04,116.96 107.04,117.16 106.93,117.26 105.68,117.26 105.41,117.53 105.41,117.96 105.68,118.23 106.93,118.23 107.04,118.33 107.04,118.53 106.93,118.63 105.68,118.63 105.41,118.9 105.41,119.33 105.68,119.6 106.93,119.6 107.04,119.7 107.04,119.9 106.93,120 105.68,120 105.41,120.27 105.41,120.7 105.68,120.97 106.93,120.97 107.04,121.07 107.04,121.27 106.93,121.38 105.68,121.38 105.41,121.64 105.41,122.08 105.68,122.34 106.93,122.34 107.04,122.44 107.04,122.65 106.93,122.75 105.68,122.75 105.41,123.01 105.41,123.45 105.68,123.71 106.93,123.71 107.04,123.81 107.04,124.02 106.93,124.12 105.68,124.12 105.41,124.38 105.41,124.82 105.68,125.08 106.93,125.08 107.04,125.19 107.04,125.39 106.93,125.49 105.68,125.49 105.41,125.76 105.41,126.19 105.68,126.46 106.93,126.46 107.04,126.56 107.04,126.76 106.93,126.86 105.68,126.86 105.41,127.13 105.41,127.56 105.68,127.83 106.93,127.83 107.04,127.93 107.04,128.13 106.93,128.23 105.68,128.23 105.41,128.5 105.41,128.93 105.68,129.2 105.89,129.2 106.73,130.04 106.73,130.26 98.42,138.57 98.42,140.91 98.89,141.38 100.97,141.38 101.05,141.47 101.05,141.69 v1(100.78,141.96)
  BOTTOM w0.114: J3.77 101.07,144.08 101.07,142.24 v1(100.78,141.96)
INPUT31_M: length 118.4
  TOP w0.114: U5.F6 v2(119.95,88.2)
  L4-SIG2 w0.102: v1(100.11,140.59) 99.82,140.3 99.82,139.76 110.66,128.92 110.66,128.18 110.4,127.92 109.01,127.92 108.91,127.81 108.91,127.61 109.01,127.51 110.4,127.51 110.66,127.24 110.66,126.81 110.4,126.54 109.01,126.54 108.91,126.44 108.91,126.24 109.01,126.14 110.4,126.14 110.66,125.87 110.66,125.44 110.4,125.17 109.01,125.17 108.91,125.07 108.91,124.87 109.01,124.77 110.4,124.77 110.66,124.5 110.66,124.07 110.4,123.8 109.01,123.8 108.91,123.7 108.91,123.5 109.01,123.4 110.4,123.4 110.66,123.13 110.66,122.7 110.4,122.43 109.01,122.43 108.91,122.33 108.91,122.13 109.01,122.02 110.4,122.02 110.66,121.76 110.66,121.32 110.4,121.06 109.01,121.06 108.91,120.96 108.91,120.75 109.01,120.65 110.4,120.65 110.66,120.39 110.66,119.95 110.4,119.69 109.01,119.69 108.91,119.59 108.91,119.38 109.01,119.28 110.4,119.28 110.66,119.02 110.66,118.58 110.4,118.32 109.01,118.32 108.91,118.21 108.91,118.01 109.01,117.91 110.4,117.91 110.66,117.64 110.66,117.21 110.4,116.94 109.01,116.94 108.91,116.84 108.91,116.64 109.01,116.54 110.4,116.54 110.66,116.27 110.66,115.84 110.4,115.57 109.01,115.57 108.91,115.47 108.91,115.27 109.01,115.17 110.4,115.17 110.66,114.9 110.66,114.47 110.4,114.2 109.01,114.2 108.91,114.1 108.91,113.9 109.01,113.79 110.4,113.79 110.66,113.53 110.66,113.09 110.4,112.83 109.01,112.83 108.91,112.73 108.91,112.52 109.01,112.42 110.4,112.42 110.66,112.16 110.66,111.72 110.4,111.46 109.01,111.46 108.91,111.36 108.91,111.15 109.01,111.05 110.4,111.05 110.66,110.79 110.66,110.35 110.4,110.09 109.01,110.09 108.91,109.98 108.91,109.78 109.01,109.68 110.4,109.68 110.66,109.41 110.66,108.98 110.4,108.71 109.01,108.71 108.91,108.61 108.91,108.41 109.01,108.31 110.4,108.31 110.66,108.04 110.66,107.61 110.4,107.34 109.01,107.34 108.91,107.24 108.91,107.04 109.01,106.94 110.4,106.94 110.66,106.67 110.66,106.24 110.4,105.97 109.01,105.97 108.91,105.87 108.91,105.67 109.01,105.56 110.26,105.56 110.66,105.16 110.66,104.38 116.2,98.83 116.2,98.23 116.74,97.69 116.8,97.63 116.84,97.63 117.19,97.27 117.36,97.11 117.36,97.07 118.31,96.12 118.39,96.04 118.39,95.47 119.53,94.31 119.53,94.08 119.53,93.9 119.57,93.87 119.57,87.9 119.68,87.78 119.86,87.78 119.94,87.86 119.94,88.19 v2(119.95,88.2)
  BOTTOM w0.114: J3.81 99.85,144.1 99.85,140.85 v1(100.11,140.59)
